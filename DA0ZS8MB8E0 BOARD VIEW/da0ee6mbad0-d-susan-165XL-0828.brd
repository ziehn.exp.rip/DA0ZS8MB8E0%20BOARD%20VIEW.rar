# Allegro board da0ee6mbad0-d-susan-165XL-0828.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
M_1_DQ13: length 21.4
  IN4 w0.06: v8(37.51,53.16) 37.89,53.16 37.97,53.08 37.97,52.83 38.05,52.76 38.25,52.76 38.33,52.68 38.33,52.58 38.25,52.5 38.07,52.5 38,52.43 38,52.31 38.07,52.23 38.28,52.23 38.38,52.13 ; v8(47.98,57.65) 47.98,57.37 48.18,57.17 48.18,57 48.06,56.89 48.06,56.31 48.26,56.12 48.26,54.76
  IN4 w0.064: 48.26,54.76 48.26,52.4 48.16,52.3 48.16,52.17 48.26,52.07 48.26,51.98 48.26,51.84 48.26,51.55 47.85,51.14 47.71,51.14 47.61,51.04 47.61,50.97 47.61,50.83 47.21,50.42 47.01,50.42 46.93,50.34 46.93,50.29 46.93,50.14 46.52,49.73 46.02,49.73 45.87,49.89 45.72,49.89 45.56,49.73 45.41,49.73 45.3,49.84 45.18,49.84 45.07,49.73 44.9,49.73 44.79,49.84 44.67,49.84 44.56,49.73 44.39,49.73 44.28,49.84 44.16,49.84 44.06,49.73 43.88,49.73 43.78,49.84 43.66,49.84 43.55,49.73 43.38,49.73 43.27,49.84 43.15,49.84 43.04,49.73 42.87,49.73 42.76,49.84 42.64,49.84 42.53,49.73 42.36,49.73 42.25,49.84 42.13,49.84 42.02,49.73 41.85,49.73 41.74,49.84 41.62,49.84 41.52,49.73 41.34,49.73 41.24,49.84 41.12,49.84 41.01,49.73 40.78,49.73 38.38,52.13
M_1_DQ14: length 22.2
  IN4 w0.06: 48.66,54.76 48.66,56.05 48.35,56.36 48.35,56.53 48.46,56.65 48.46,56.89 48.33,57.02 48.33,57.3 v8(48.26,57.37) ; 37.56,51.79 37.51,51.85 v8(37.51,52.66)
  IN4 w0.064: 37.56,51.79 37.79,51.56 37.9,51.56 38.08,51.74 38.18,51.74 38.26,51.66 38.26,51.56 38.08,51.38 38.08,51.28 38.15,51.2 38.26,51.2 38.44,51.38 38.54,51.38 38.62,51.3 38.62,51.2 38.44,51.02 38.44,50.92 38.51,50.84 38.62,50.84 38.79,51.02 38.9,51.02 38.97,50.94 38.97,50.84 38.78,50.65 38.78,50.57 39.87,49.48 39.98,49.48 40.13,49.63 40.28,49.63 40.59,49.33 46.68,49.33 48.66,51.31 48.66,54.76
M_1_DQ15: length 22.4
  IN4 w0.06: v8(48.55,57.65) 48.55,57.37 48.76,57.15 48.76,57.02 48.59,56.85 48.59,56.69 48.97,56.31 48.97,55.2 49.37,54.79 49.37,54.76 ; v8(36.51,52.66) 36.75,52.42 36.75,52.05 37,51.79
  IN4 w0.064: 49.37,54.76 49.37,51.44 46.89,48.95 39.85,48.95 37,51.79
M_1_DQ16: length 20.5
  IN3 w0.06: v8(48.55,58.79) 48.79,58.54 48.79,56.52 48.94,56.37 48.94,55.91 ; v8(36.01,53.66) 36.01,52.65 36.76,51.89
  IN3 w0.064: 36.76,51.89 37.42,51.23 45.97,51.23 48.52,53.79 48.52,54.88 48.94,55.3 48.94,55.91
M_1_DQ17: length 21.2
  IN3 w0.06: 48.36,55.91 48.36,56.14 48.26,56.23 v8(48.26,57.94) ; 38.27,51.92 38.25,51.92 38.15,52.02 38.15,52.15 37.61,52.68 36.79,52.68 36.54,52.94 36.54,54.13 v8(36.51,54.16)
  IN3 w0.064: 38.27,51.92 38.66,51.92 38.76,51.82 38.91,51.82 39.01,51.92 39.16,51.92 39.27,51.82 39.42,51.82 39.52,51.92 39.67,51.92 39.78,51.82 39.93,51.82 40.03,51.92 40.18,51.92 40.28,51.82 40.43,51.82 40.54,51.92 40.69,51.92 40.79,51.82 40.94,51.82 41.05,51.92 41.2,51.92 41.3,51.82 41.45,51.82 41.55,51.92 41.7,51.92 41.81,51.82 41.96,51.82 42.06,51.92 42.21,51.92 42.32,51.82 42.47,51.82 42.57,51.92 42.72,51.92 42.82,51.82 42.97,51.82 43.08,51.92 43.23,51.92 43.33,51.82 43.48,51.82 43.59,51.92 43.74,51.92 43.84,51.82 43.99,51.82 44.09,51.92 44.24,51.92 44.35,51.82 44.5,51.82 44.6,51.92 44.75,51.92 44.86,51.82 45.01,51.82 45.11,51.92 45.26,51.92 45.36,51.82 45.51,51.82 45.64,51.94 45.64,52.07 45.74,52.17 45.91,52.17 45.96,52.12 46.05,52.12 46.12,52.19 46.12,52.28 46.03,52.37 46.03,52.46 46.1,52.52 46.19,52.52 46.27,52.44 46.36,52.44 46.43,52.51 46.43,52.6 46.34,52.68 46.34,52.77 46.41,52.84 46.5,52.84 46.59,52.75 46.68,52.75 46.74,52.82 46.74,52.91 46.66,53 46.66,53.09 46.72,53.15 46.82,53.15 46.9,53.07 46.99,53.07 47.06,53.13 47.06,53.23 46.95,53.33 46.95,53.42 47.02,53.49 47.11,53.49 47.22,53.38 47.31,53.38 47.37,53.45 47.37,53.54 47.33,53.59 47.33,53.68 47.39,53.74 47.48,53.74 47.53,53.7 47.62,53.7 47.69,53.76 47.69,53.85 47.64,53.9 47.64,53.99 47.71,54.07 47.71,55.04 48.36,55.68 48.36,55.91
M_1_DQ18: length 20.5
  IN3 w0.06: 47.09,55.91 47.25,56.06 47.55,56.06 47.62,56.13 47.62,56.24 47.55,56.31 47.29,56.31 47.22,56.38 47.22,56.48 47.29,56.55 47.63,56.55 47.7,56.62 47.7,56.72 47.63,56.79 47.29,56.79 47.22,56.86 47.22,56.96 47.29,57.03 47.63,57.03 47.7,57.1 47.7,57.18 47.52,57.35 47.52,57.48 47.7,57.66 v8(47.7,58.5) ; v8(37.27,53.91) 37.27,53.79 37.64,53.42 37.74,53.42 37.8,53.48 37.8,53.58 37.86,53.65 37.96,53.65 38.02,53.58 38.02,53.48 38.08,53.42 38.22,53.42 38.27,53.37
  IN3 w0.064: 47.09,55.91 46.48,55.29 46.48,55.2 46.55,55.12 46.55,55.03 46.46,54.94 46.37,54.94 46.29,55.02 46.2,55.02 46.12,54.94 46.12,54.84 46.19,54.77 46.19,54.67 46.11,54.59 46.01,54.59 45.94,54.66 45.84,54.66 45.76,54.58 45.76,54.48 45.83,54.41 45.83,54.31 45.75,54.23 45.65,54.23 45.58,54.3 45.48,54.3 45.4,54.22 45.4,54.12 45.74,53.78 45.74,53.67 45.68,53.61 45.59,53.61 45.37,53.82 45.28,53.82 45.22,53.76 45.22,53.66 45.43,53.45 45.43,53.36 45.36,53.29 45.27,53.29 45.06,53.51 44.97,53.51 44.9,53.44 44.9,53.35 45.12,53.14 45.12,53.05 45.03,52.96 44.74,52.96 44.67,53.03 44.67,53.2 44.61,53.27 44.51,53.27 44.45,53.2 44.45,53.03 44.38,52.96 38.68,52.96 38.27,53.37
  BOTTOM w0.114: v8(37.27,53.91) 37.02,54.16 U24.E15
M_1_DQ19: length 19.8
  IN3 w0.06: v8(47.42,59.35) 47.42,59.35 47.42,60.1 47.62,60.3 47.62,60.81 47.72,60.91 48.1,60.91 48.18,60.83 48.18,60.71 48.1,60.63 48,60.63 47.93,60.56 47.93,60.45 48,60.38 48.1,60.38 48.18,60.3 48.18,60.18 48.1,60.1 47.92,60.1 47.85,60.02 47.85,59.92 47.92,59.84 48.11,59.84 48.18,59.77 48.18,59.66 48.11,59.59 47.85,59.59 47.75,59.49 47.75,59.11 47.62,58.97 47.62,58.7 47.5,58.59 47.5,58.41 47.58,58.33 47.58,57.74 47.03,57.2 47.03,56.13 46.81,55.91 ; v8(37.51,54.16) 37.51,53.93 37.63,53.8 38.05,53.8 38.25,53.6 38.27,53.6
  IN3 w0.064: 38.27,53.6 38.35,53.6 38.63,53.32 38.91,53.32 39.06,53.16 44.14,53.16 44.45,53.47 44.64,53.47 45.16,53.98 45.16,54.25 46.81,55.91
M_1_DQ20: length 19.7
  IN3 w0.06: 46.26,55.91 46.79,56.45 46.79,57.32 47.33,57.85 47.33,58.2 47.13,58.4 v8(47.13,58.5) ; 38.27,54.31 37.42,55.16 37.3,55.16 37.22,55.08 37.22,54.91 37.46,54.66 v8(37.51,54.66)
  IN3 w0.064: 38.27,54.31 38.58,54 40.57,54 40.64,53.94 40.64,53.64 40.7,53.57 40.8,53.57 40.86,53.64 40.86,53.94 40.93,54 41.02,54 41.08,53.94 41.08,53.64 41.15,53.57 41.24,53.57 41.31,53.64 41.31,53.94 41.37,54 41.46,54 41.53,53.94 41.53,53.64 41.59,53.57 41.69,53.57 41.75,53.64 41.75,53.94 41.82,54 41.91,54 41.97,53.94 41.97,53.64 42.04,53.57 42.13,53.57 42.19,53.64 42.19,53.94 42.26,54 42.35,54 42.42,53.94 42.42,53.64 42.48,53.57 42.57,53.57 42.64,53.64 42.64,53.94 42.7,54 42.8,54 42.86,53.94 42.86,53.64 42.93,53.57 43.02,53.57 43.08,53.64 43.08,53.94 43.15,54 43.24,54 43.31,53.94 43.31,53.64 43.37,53.57 43.46,53.57 43.53,53.64 43.53,53.94 43.59,54 43.69,54 43.75,53.94 43.75,53.64 43.82,53.57 43.91,53.57 43.97,53.64 43.97,53.94 44.04,54 44.35,54 46.26,55.91
M_1_DQ21: length 20.8
  IN3 w0.06: v8(48.26,59.07) 48.26,58.79 48.46,58.59 48.46,58.42 48.35,58.3 48.35,58.14 48.49,58 48.49,56.31 48.56,56.24 48.56,55.91 ; v8(36.51,54.66) 36.31,54.46 36.31,54.07 36.38,53.99 36.38,52.85 36.7,52.53 37.44,52.53 37.92,52.05 37.92,51.89
  IN3 w0.064: 37.92,51.89 38.2,51.61 45.81,51.61 47.93,53.73 47.93,54.98 48.56,55.62 48.56,55.91
M_1_DQ22: length 20
  IN3 w0.06: 37.64,51.89 37.64,52 37.23,52.4 36.6,52.4 36.23,52.77 36.23,53.72 35.96,53.99 35.96,54.12 v8(36.01,54.16) ; 48.76,55.91 48.76,56.32 48.64,56.44 48.64,58.13 v8(48.55,58.22)
  IN3 w0.064: 48.76,55.91 48.76,55.55 48.13,54.92 48.13,54.18 48.28,54.03 48.28,53.81 45.89,51.42 38.03,51.42 37.64,51.82 37.64,51.89
M_1_DQ23: length 18.9
  IN3 w0.06: v8(37.25,54.42) 37.29,54.46 37.69,54.46 37.74,54.41 37.74,53.99 37.81,53.93 37.9,53.93 37.97,53.99 37.97,54.13 38.02,54.18 38.12,54.18 38.19,54.12 38.19,53.86 38.25,53.8 38.27,53.8 ; 46.53,55.91 46.91,56.29 46.91,57.27 47.45,57.8 47.45,58.29 47.38,58.36 47.33,58.41 47.33,58.61 47.29,58.65 47.29,58.75 47.33,58.79 v8(47.42,58.79)
  IN3 w0.064: 46.53,55.91 44.91,54.29 44.91,54.19 44.96,54.15 44.96,54.06 44.89,53.99 44.8,53.99 44.76,54.04 44.66,54.04 44.6,53.97 44.6,53.88 44.65,53.83 44.65,53.74 44.58,53.68 44.49,53.68 44.37,53.8 44.27,53.8 44.2,53.73 44.2,53.5 44.07,53.37 40.51,53.37 40.45,53.43 40.45,53.74 40.38,53.81 40.28,53.81 40.21,53.74 40.21,53.42 40.15,53.35 40.05,53.35 39.99,53.42 39.99,53.75 39.92,53.81 39.83,53.81 39.77,53.75 39.77,53.42 39.7,53.35 39.61,53.35 39.55,53.42 39.55,53.75 39.48,53.81 39.39,53.81 39.32,53.75 39.32,53.42 39.26,53.35 39.17,53.35 39.1,53.42 39.1,53.75 39.04,53.81 38.94,53.81 38.88,53.75 38.88,53.58 38.81,53.52 38.72,53.52 38.66,53.58 38.66,53.75 38.6,53.8 38.27,53.8
  BOTTOM w0.114: v8(37.25,54.42) 37.12,54.42 37.01,54.54 U24.F15
M_1_DQ24: length 15.1
  IN3 w0.06: 38.23,58.41 v8(37.75,58.41) ; 43.89,56.41 43.89,56.59 43.94,56.64 44.6,56.64 45.59,57.63 45.59,58.14 45.67,58.22 v8(45.72,58.22)
  IN3 w0.064: 43.89,56.41 43.83,56.34 43.73,56.34 43.58,56.5 43.49,56.5 43.42,56.43 43.42,56.34 43.58,56.19 43.58,56.09 43.48,56 43.3,56 43.19,56.11 43.05,56.11 42.94,56 42.79,56 42.68,56.11 42.54,56.11 42.43,56 42.28,56 42.17,56.11 42.03,56.11 41.92,56 41.78,56 41.67,56.11 41.55,56.11 41.44,56 41.31,56 41.2,56.11 41.07,56.11 40.96,56 40.8,56 40.69,56.11 40.56,56.11 40.45,56 40.34,56 40.24,56.1 40.24,56.28 40.14,56.38 40.05,56.38 39.95,56.48 39.95,56.59 40.02,56.66 40.06,56.66 40.13,56.72 40.13,56.81 40.06,56.88 40.02,56.88 39.95,56.94 39.95,57.04 40.02,57.1 40.06,57.1 40.13,57.17 40.13,57.26 40.06,57.32 40.02,57.32 39.95,57.39 39.95,57.48 40.02,57.55 40.06,57.55 40.13,57.61 40.13,57.83 39.87,58.08 39.87,58.19 39.93,58.24 40.48,58.24 40.55,58.31 40.55,58.41 40.48,58.49 39.54,58.49 39.43,58.37 39.29,58.37 39.17,58.49 39.03,58.49 38.92,58.37 38.78,58.37 38.67,58.49 38.53,58.49 38.41,58.37 38.27,58.37 38.23,58.41
  BOTTOM w0.114: U24.N16 37.51,58.29 37.59,58.37 37.72,58.37 v8(37.75,58.41)
M_1_DQ25: length 15.9
  IN3 w0.06: 45.37,55.91 46.4,56.94 46.4,57.44 46.77,57.81 46.77,58.14 v8(46.85,58.22) ; v8(36.51,58.16) 36.14,58.53 36.02,58.53 35.93,58.44 35.93,58.32 36.32,57.94 36.32,57.56 36.47,57.41 36.57,57.41 36.73,57.25 36.73,57.08 36.62,56.97 36.62,56.81 38.27,55.16
  IN3 w0.064: 45.37,55.91 44.08,54.61 38.82,54.61 38.27,55.16
M_1_DQ26: length 15.2
  IN3 w0.06: v8(47.13,57.94) 47.05,57.75 46.67,57.37 46.67,56.67 45.91,55.91 ; v8(35.98,57.66) 35.79,57.46 35.79,57.1 38.27,54.61
  IN3 w0.064: 45.91,55.91 44.24,54.23 38.65,54.23 38.27,54.61
M_1_DQ27: length 15.3
  IN3 w0.06: 45.64,55.91 46.55,56.82 46.55,57.42 46.9,57.77 46.9,57.99 47.05,58.14 47.05,58.3 46.93,58.42 46.93,58.87 v8(47.13,59.07) ; 38.27,54.89 v8(36.01,57.16)
  IN3 w0.064: 45.64,55.91 44.16,54.42 38.74,54.42 38.27,54.89
M_1_DQ28: length 15.1
  IN3 w0.06: v8(46.57,58.5) 46.63,58.5 46.68,58.45 46.68,58.34 46.36,58.01 46.36,57.84 46.15,57.63 46.15,57.25 44.81,55.91 ; v8(37.01,58.16) 37.11,58.06 37.11,57.99 37.03,57.91 36.93,57.91 36.78,58.07 36.7,58.07 36.62,57.99 36.62,57.89 36.79,57.72 36.79,57.6 37.16,57.23 37.16,56.71 37.53,56.34 38.27,56.34
  IN3 w0.064: 44.81,55.91 43.9,55 39.21,55 39.14,55.07 39.14,55.18 39.24,55.28 39.24,55.77 38.87,56.14 38.87,56.25 38.79,56.34 38.27,56.34
M_1_DQ29: length 14.7
  IN3 w0.06: 38.27,58.68 37.52,58.68 v8(37.51,58.66) ; 43.51,57.43 43.66,57.43 43.74,57.35 43.74,56.92 43.81,56.85 44.55,56.85 45.46,57.76 45.46,58.25 45.72,58.5 v8(45.72,58.79)
  IN3 w0.064: 43.51,57.43 43.48,57.43 43.42,57.37 43.42,56.7 43.02,56.3 40.55,56.3 40.33,56.52 40.33,57.82 40.63,58.13 41.17,58.13 41.27,58.23 41.27,58.57 41.17,58.68 38.27,58.68
M_1_DQ30: length 14.8
  IN3 w0.06: 45.1,55.91 46.28,57.08 46.28,57.56 46.54,57.83 v8(46.57,57.94) ; v8(36.53,57.66) 36.53,57.64 36.98,57.19 36.98,57.08 36.83,56.92 36.83,56.82 37.51,56.14 37.77,56.14 37.84,56.06 37.84,55.82 37.91,55.75 38,55.75 38.07,55.82 38.07,56.06 38.15,56.14 38.25,56.14 38.27,56.11
  IN3 w0.064: 38.27,56.11 38.3,56.08 38.43,56.08 38.48,56.14 38.61,56.14 39.03,55.71 39.03,55.39 38.73,55.09 38.73,54.98 38.9,54.81 44,54.81 45.1,55.91
M_1_DQ31: length 15.5
  IN3 w0.06: v8(45.44,58.5) 45.34,58.4 45.34,57.91 44.47,57.05 43.96,57.05 43.89,57.13 43.89,57.51 43.76,57.63 43.51,57.63 ; 38.27,58.88 37.64,58.88 37.56,58.95 36.84,58.95 36.75,58.87 36.75,58.75 36.84,58.66 v8(37.01,58.66)
  IN3 w0.064: 38.27,58.88 41.4,58.88 41.5,58.78 41.5,58.04 41.4,57.94 40.71,57.94 40.52,57.74 40.52,56.64 40.66,56.49 42.94,56.49 43.23,56.78 43.23,57.56 43.3,57.63 43.51,57.63
M_1_DQ32: length 13.3
  IN3 w0.06: 42.67,59.11 42.92,59.11 43.1,59.29 43.45,59.29 44.86,60.7 45.72,60.7 45.83,60.66 45.88,60.61 46.16,60.61 v8(46.28,60.48) ; v8(34.51,58.16) 34.51,58.37 34.6,58.46 34.93,58.46 35.91,59.44 36.93,59.44 37.16,59.21 38.27,59.21
  IN3 w0.064: 38.27,59.21 38.43,59.21 38.53,59.11 42.67,59.11
M_1_DQ33: length 13.6
  IN3 w0.06: v8(46.85,60.48) 46.6,60.73 46.03,60.73 45.87,60.78 45.75,60.82 44.81,60.82 43.43,59.44 43.02,59.44 42.9,59.31 ; v8(34.53,58.66) 34.88,58.66 35.84,59.62 37.08,59.62 37.28,59.41 38.27,59.41
  IN3 w0.064: 38.27,59.41 38.55,59.41 38.66,59.31 42.9,59.31
M_1_DQ34: length 14.6
  IN3 w0.06: 34.25,60.45 v8(34.25,59.91) ; v8(46.57,61.9) 46.28,61.9 46.08,61.7 45.92,61.7 45.8,61.82 45.64,61.82 45.52,61.7 44.34,61.7 43.61,60.96 43.38,60.96
  IN3 w0.064: 43.38,60.96 43.37,60.95 39.4,60.95 38.6,61.75 35.48,61.75 34.25,60.52 34.25,60.45
  BOTTOM w0.114: U24.T10 v8(34.25,59.91)
M_1_DQ35: length 13.3
  IN3 w0.06: v8(34.53,59.16) 34.59,59.16 34.82,59.39 35.02,59.39 36.08,60.45 ; 36.34,60.45 36.52,60.28 37.87,60.28 38.02,60.43 38.21,60.43 38.27,60.36 ; 42.67,59.72 43.37,59.72 44.71,61.06 45.81,61.06 45.95,61.01 46.24,61.01 v8(46.28,61.05)
  IN3 w0.064: 42.67,59.72 38.92,59.72 38.27,60.36 ; 36.08,60.45 36.13,60.5 36.3,60.5 36.34,60.45
M_1_DQ36: length 14.1
  IN3 w0.06: v8(46.85,61.05) 46.91,60.99 46.91,60.91 46.85,60.85 46.08,60.85 45.91,60.89 45.78,60.94 44.76,60.94 43.39,59.56 42.9,59.56 42.85,59.51 42.67,59.51 ; 35.1,59.18 35.08,59.16 v8(34.98,59.16) ; 38.22,60.05 36.67,60.05 36.62,60 36.62,59.87 36.54,59.79 36.43,59.79 36.34,59.87 36.34,60.15 36.27,60.22 36.17,60.22 36.1,60.15 36.1,59.89 36,59.79 35.71,59.79
  IN3 w0.064: 35.1,59.18 35.71,59.79 ; 42.67,59.51 38.76,59.51 38.22,60.05
M_1_DQ37: length 14.2
  IN3 w0.06: 43.38,61.15 43.39,61.16 43.63,61.16 44.37,61.9 v8(45.44,61.9) ; 34.01,60.45 34.01,59.82 33.77,59.58 v8(33.77,59.4)
  IN3 w0.064: 34.01,60.45 34.01,60.56 35.41,61.96 38.66,61.96 39.47,61.15 43.38,61.15
  BOTTOM w0.114: U24.R9 v8(33.77,59.4)
M_1_DQ38: length 14.6
  IN3 w0.06: 43.38,61.36 43.39,61.37 43.66,61.37 44.31,62.02 45.27,62.02 45.35,62.1 45.68,62.1 45.8,61.98 v8(46,61.9) ; v8(33.77,59.91) 33.79,59.93 33.79,60.45
  IN3 w0.064: 43.38,61.36 39.53,61.36 38.73,62.16 35.34,62.16 33.79,60.61 33.79,60.45
  BOTTOM w0.114: U24.T9 v8(33.77,59.91)
M_1_DQ39: length 14.5
  IN3 w0.06: 35.8,60.45 35.13,59.79 35.11,59.79 v8(34.99,59.66) ; v8(46.85,61.62) 46.85,61.36 46.78,61.29 46.24,61.29 46.08,61.13 45.97,61.13 45.83,61.18 44.66,61.18 43.4,59.92 42.67,59.92
  IN3 w0.064: 35.8,60.45 36.08,60.73 36.47,60.73 36.54,60.66 36.54,60.55 36.62,60.48 36.72,60.48 36.8,60.55 36.8,60.66 36.87,60.73 36.98,60.73 37.05,60.66 37.05,60.55 37.13,60.48 37.23,60.48 37.31,60.55 37.31,60.66 37.38,60.73 37.49,60.73 37.56,60.66 37.56,60.55 37.63,60.48 37.74,60.48 37.81,60.55 37.81,60.66 37.89,60.73 38.17,60.73 38.99,59.92 42.67,59.92
M_1_DQ40: length 13.7
  IN4 w0.06: v8(44.87,60.77) 45.15,60.77 45.68,61.3 45.68,61.37 45.5,61.55 45.37,61.55 44.67,60.85 44.5,60.85 44.42,60.93 43.32,60.93 42.59,60.2 42.39,60.2 42.24,60.05 42.24,59.84 42.14,59.74 ; v8(36.01,59.66) 36.01,59.86 36.24,60.1 36.24,60.33 36.29,60.38 37.36,60.38 37.54,60.2 37.92,60.2 38,60.28 38,60.35 38.07,60.43 38.25,60.43 38.38,60.3
  IN4 w0.064: 38.38,60.3 38.5,60.3 38.58,60.23 38.58,59.79 38.93,59.44 39.65,59.44 39.91,59.17 40.47,59.17 40.61,59.31 40.74,59.31 40.88,59.17 41.44,59.17 41.81,59.53 41.81,59.64 41.86,59.69 42.08,59.69 42.14,59.74
M_1_DQ41: length 13.5
  IN4 w0.06: 38.38,59.73 38.38,60.13 38.3,60.2 38.2,60.2 38.12,60.13 38.12,59.82 38.05,59.74 37.94,59.74 37.87,59.82 37.87,60 37.79,60.07 37.31,60.07 37.13,59.89 36.93,59.89 36.81,59.78 36.71,59.78 36.65,59.85 36.65,59.94 36.79,60.08 36.79,60.19 36.72,60.26 36.61,60.26 36.24,59.89 36.24,59.51 36.32,59.44 36.65,59.44 36.8,59.29 36.8,59.11 36.57,58.88 36.37,58.88 36.09,59.16 v8(36.01,59.16) ; v8(44.27,60.73) 44.19,60.81 43.41,60.81 42.62,60.02 42.49,60.02 42.41,59.95 42.41,59.77 42.14,59.49
  IN4 w0.064: 38.38,59.73 38.87,59.23 39.49,59.23 39.57,59.16 39.57,59.06 39.65,58.98 40.56,58.98 40.64,59.06 40.71,59.06 40.79,58.98 41.52,58.98 42.03,59.49 42.14,59.49
M_1_DQ42: length 13.6
  IN4 w0.06: v8(44.87,60.2) 44.79,60.28 44.5,60.28 44.44,60.35 44.38,60.41 44.15,60.41 44.03,60.28 43.86,60.28 43.7,60.45 43.58,60.45 43.23,60.1 43.23,59.92 42.19,58.88 42.19,58.8 42.14,58.75 ; v8(36.01,58.66) 36.01,58.45 35.93,58.37 35.81,58.37 35.73,58.29 35.73,57.63 35.59,57.48 35.59,57.38 35.67,57.29 35.78,57.29 35.9,57.41 36.19,57.41 36.27,57.48 36.27,57.81 36.34,57.89 36.57,57.89 36.75,58.07 36.75,58.27 36.9,58.42 37.21,58.42 37.28,58.35 37.28,58.27 37.36,58.19 38,58.19 38.1,58.29 38.38,58.29
  IN4 w0.064: 38.38,58.29 40.71,58.29 40.92,58.09 41.14,58.09 41.22,58.02 41.22,57.94 41.3,57.86 41.47,57.86 41.55,57.94 41.55,58.17 42.14,58.75
M_1_DQ43: length 12.6
  IN4 w0.06: v8(45.15,60.48) 45.22,60.56 45.51,60.56 45.66,60.71 45.78,60.71 45.92,60.57 45.92,60.56 45.92,60.56 45.92,60.4 45.7,60.18 45.17,60.18 44.67,60.68 44.5,60.68 44.35,60.53 44.18,60.53 44.11,60.6 44.02,60.69 43.46,60.69 42.9,60.12 42.9,60.02 42.14,59.26 ; 38.38,59.46 38.22,59.62 37.84,59.62 37.59,59.87 37.36,59.87 37.26,59.77 37.26,59.62 37.03,59.39 36.9,59.39 36.63,59.66 v8(36.51,59.66)
  IN4 w0.064: 38.38,59.46 38.8,59.03 39.29,59.03 39.53,58.79 41.6,58.79 42.06,59.25 42.12,59.25 42.14,59.26
M_1_DQ44: length 14.1
  IN4 w0.06: 34.74,60.45 34.74,58.52 34.87,58.4 35.1,58.4 35.25,58.24 35.25,57.81 35.33,57.74 35.43,57.74 35.51,57.81 v8(35.51,58.16) ; 41.17,61.2 41.41,60.96 41.6,60.96 41.7,61.06 41.7,61.29 41.78,61.37 42.24,61.37 42.39,61.22 42.64,61.22 43.04,61.62 v8(43.95,61.62)
  IN4 w0.064: 41.17,61.2 41.12,61.25 39.59,61.25 39.34,61.49 35.76,61.49 34.74,60.48 34.74,60.45
M_1_DQ45: length 14.1
  IN4 w0.06: 41.17,61.44 41.27,61.44 41.32,61.49 42.71,61.49 42.95,61.74 43.76,61.74 43.85,61.82 44.05,61.82 44.17,61.7 44.39,61.7 44.59,61.9 v8(44.87,61.9) ; v8(35.01,58.16) 34.88,58.16 34.64,58.4 34.46,58.4 34.33,58.53 34.33,59.41 34.46,59.54 34.46,60.45
  IN4 w0.064: 34.46,60.45 34.46,60.48 35.67,61.69 39.5,61.69 39.74,61.44 41.17,61.44
M_1_DQ46: length 13.9
  IN4 w0.06: v8(45.15,61.62) 44.87,61.62 44.67,61.42 44.5,61.42 44.35,61.57 44.18,61.57 44.03,61.42 43.05,61.42 42.46,60.83 42.26,60.83 42.19,60.9 42.19,61.15 42.12,61.22 42.02,61.22 41.95,61.15 41.95,60.9 41.88,60.83 41.27,60.83 41.17,60.93 ; v8(35.51,58.66) 35.34,58.66 35.19,58.82 35.19,59.78 34.92,60.05 34.92,60.38 35,60.45
  IN4 w0.064: 35,60.45 35.85,61.3 39.26,61.3 39.51,61.06 41.05,61.06 41.17,60.93
M_1_DQ47: length 13.9
  IN4 w0.06: v8(43.95,60.48) 43.86,60.57 43.52,60.57 43.04,60.09 43.04,59.96 42.14,59.06 ; 37.68,58.89 37.64,58.93 36.83,58.93 36.75,58.85 36.75,58.47 36.67,58.4 36.45,58.4 36.33,58.28 36.23,58.28 36.14,58.37 36.14,58.48 36.22,58.55 36.22,58.83 36.14,58.9 35.79,58.9 35.71,58.98 35.71,59.36 35.79,59.44 36.14,59.44 36.22,59.36 36.22,59.24 36.29,59.16 v8(36.51,59.16)
  IN4 w0.064: 37.68,58.89 37.72,58.85 37.72,58.7 37.79,58.62 37.89,58.62 37.97,58.7 37.97,58.85 38.05,58.93 38.17,58.93 38.25,58.85 38.25,58.57 38.33,58.5 38.43,58.5 38.51,58.57 38.51,58.76 38.58,58.84 38.68,58.84 38.76,58.76 38.76,58.57 38.84,58.5 38.94,58.5 39.01,58.57 39.01,58.76 39.09,58.84 39.19,58.84 39.27,58.76 39.27,58.57 39.34,58.5 40.51,58.5 40.61,58.6 41.2,58.6 41.27,58.52 41.27,58.42 41.35,58.35 41.45,58.35 41.53,58.42 41.53,58.52 41.6,58.6 41.68,58.6 42.14,59.06
M_1_DQ48: length 22.5
  IN4 w0.06: 32.51,60.45 32.51,60.3 32.58,60.22 32.66,60.22 32.74,60.15 32.74,60.02 32.66,59.95 32.58,59.95 32.51,59.87 v8(32.51,59.66) ; 41.17,62.01 41.24,62.01 41.35,61.9 41.55,61.9 41.88,62.23 42.95,62.23 43.18,62.46 43.6,62.46 43.75,62.31 44.18,62.31 44.22,62.26 44.39,62.26 44.51,62.39 44.66,62.39 45.35,61.7 45.36,61.7 45.52,61.7 45.66,61.84 45.78,61.84 45.94,61.67 46.06,61.67 47.07,62.68 47.07,62.81 46.63,63.25 46.5,63.25 45.44,62.18 v8(45.15,62.18)
  IN4 w0.064: 32.51,60.45 32.51,60.48 32.69,60.66 32.69,60.89 32.76,60.96 32.99,60.96 33.07,61.04 33.07,61.57 32.99,61.65 32.36,61.65 32.28,61.72 32.28,61.85 32.36,61.93 33.85,61.93 33.93,62 33.93,62.08 34.11,62.26 39.73,62.26 39.98,62.01 41.17,62.01
M_1_DQ49: length 23.5
  IN4 w0.06: 31.85,60.45 31.92,60.38 32.31,60.38 32.38,60.3 32.38,59.87 32.25,59.74 v8(32.25,59.41) ; 41.17,62.2 41.2,62.2 41.36,62.36 42.87,62.36 43.1,62.59 43.64,62.59 43.8,62.43 44.08,62.43 44.12,62.46 v8(44.3,62.46)
  IN4 w0.064: 31.85,60.45 31.85,60.58 31.92,60.66 32.41,60.66 32.48,60.73 32.48,60.84 32.41,60.91 31.9,60.91 31.82,60.99 31.82,61.09 31.9,61.16 32.79,61.16 32.86,61.24 32.86,61.34 32.79,61.42 31.85,61.42 31.78,61.49 31.78,61.6 31.85,61.67 32,61.67 32.08,61.75 32.08,61.85 32,61.93 30.78,61.93 30.71,62 30.71,62.11 30.78,62.18 30.91,62.18 30.98,62.26 30.98,62.34 31.06,62.42 31.16,62.42 31.24,62.34 31.24,62.26 31.31,62.18 31.41,62.18 31.49,62.26 31.49,62.34 31.57,62.42 31.67,62.42 31.74,62.34 31.74,62.26 31.82,62.18 31.92,62.18 32,62.26 32,62.34 32.07,62.42 32.18,62.42 32.25,62.34 32.25,62.22 32.32,62.16 32.42,62.16 32.48,62.22 32.48,62.34 32.55,62.41 32.64,62.41 32.71,62.33 32.71,62.21 32.79,62.13 33.7,62.13 34.02,62.45 39.81,62.45 40.06,62.2 41.17,62.2
  BOTTOM w0.114: U24.R5 v8(32.25,59.41)
M_1_DQ50: length 22.5
  IN4 w0.06: v8(31.51,58.15) U24.N4 31.32,58.35 30.65,58.35 30.6,58.4 30.48,58.4 29.61,59.26 ; v8(44.87,63.6) 44.52,63.6 44.35,63.43 44.13,63.43 44.04,63.53 43.68,63.53 43.62,63.59 41.17,63.59
  IN4 w0.064: 41.17,63.59 40.68,63.59 40.46,63.82 30.21,63.82 30.12,63.73 29.82,63.73 29.28,63.2 29.28,59.59 29.61,59.26
M_1_DQ51: length 22.9
  IN4 w0.06: v8(32.51,59.16) 32.71,59.36 33.48,59.36 33.55,59.44 33.55,59.54 33.48,59.62 32.79,59.62 32.71,59.69 32.71,59.79 32.79,59.87 33.25,59.87 33.32,59.94 33.32,60.05 33.25,60.12 33.04,60.12 32.97,60.2 32.97,60.45 ; 41.17,61.82 41.25,61.82 41.3,61.77 41.68,61.77 41.93,62.03 43.61,62.03 43.77,62.19 44.13,62.19 44.17,62.14 44.55,62.14 v8(44.59,62.18)
  IN4 w0.064: 32.97,60.45 32.97,60.56 33.04,60.63 33.99,60.63 34.06,60.71 34.06,60.78 33.99,60.86 33.35,60.86 33.27,60.93 33.27,61.04 33.35,61.11 34.52,61.11 34.59,61.18 34.59,61.28 34.52,61.34 33.35,61.34 33.27,61.42 33.27,61.52 33.35,61.6 35.03,61.6 35.1,61.66 35.1,61.76 35.03,61.83 34.2,61.83 34.13,61.9 34.13,62 34.2,62.07 39.65,62.07 39.9,61.82 41.17,61.82
M_1_DQ52: length 23.4
  IN4 w0.06: v8(44.87,62.46) 45.15,62.46 45.92,63.23 45.92,63.39 45.79,63.53 45.65,63.53 44.94,62.82 44.8,62.82 44.67,62.95 44.5,62.95 44.3,62.74 44.22,62.74 44.03,62.55 43.85,62.55 43.68,62.72 43.03,62.72 42.82,62.51 41.33,62.51 41.21,62.39 41.17,62.39 ; v8(32.01,59.66) 32.01,59.79 32.08,59.87 32.15,59.87 32.23,59.95 32.23,60.05 32.15,60.12 31.79,60.12 31.72,60.19 31.72,60.33 31.65,60.4 31.65,60.45
  IN4 w0.064: 31.65,60.45 31.65,60.61 31.57,60.68 31.29,60.68 31.21,60.76 31.21,60.86 31.29,60.94 31.47,60.94 31.54,61.01 31.54,61.12 31.47,61.19 31.29,61.19 31.21,61.26 31.21,61.37 31.29,61.44 31.47,61.44 31.54,61.52 31.54,61.65 31.47,61.72 30.58,61.72 30.5,61.8 30.5,62.18 30.93,62.61 32.71,62.61 32.99,62.33 33.63,62.33 33.93,62.64 39.94,62.64 40.19,62.39 41.17,62.39
M_1_DQ53: length 22.7
  IN4 w0.06: v8(44.3,61.9) 44.25,61.95 43.76,61.95 43.68,61.88 42.64,61.88 42.57,61.8 42.57,61.7 42.49,61.62 42.36,61.62 42.28,61.7 42.28,61.83 42.21,61.9 42.11,61.9 42.04,61.83 42.04,61.7 41.97,61.63 41.17,61.63 ; v8(32.75,58.92) 33.65,58.92 33.75,58.82 33.75,58.02 33.68,57.94 33.3,57.94 33.22,57.86 33.22,57.1 33.3,57.02 34.11,57.02 34.19,56.95 34.19,56.84 34.11,56.77 33.27,56.77 33.19,56.69 33.19,56.59 33.27,56.52 34.36,56.52 34.44,56.59 34.44,57.81 34.29,57.96 34.29,58.32 34.21,58.4 34.21,59.57 34.03,59.74 34.03,60.33
  IN4 w0.064: 34.03,60.33 35.58,61.88 39.57,61.88 39.82,61.63 41.17,61.63
  BOTTOM w0.114: U24.P6 32.75,58.9 v8(32.75,58.92)
M_1_DQ54: length 23.9
  IN4 w0.06: 41.17,63.78 43.66,63.78 43.76,63.68 44.22,63.68 v8(44.27,63.63) ; 29.61,58.7 29.92,58.4 29.92,58.22 30.32,57.81 31.66,57.81 v8(32.01,58.16)
  IN4 w0.064: 29.61,58.7 29.08,59.23 29.08,63.63 29.77,64.31 40.23,64.31 40.76,63.78 41.17,63.78
M_1_DQ55: length 23.5
  IN4 w0.06: 29.71,59.39 30.17,59.39 30.25,59.31 30.25,59.01 30.38,58.88 30.6,58.88 30.73,58.75 30.73,58.55 30.81,58.47 31.82,58.47 v8(32.01,58.66) ; v8(44.59,63.31) 43.58,63.31 43.5,63.4 41.17,63.4
  IN4 w0.064: 29.71,59.39 29.64,59.46 29.64,59.58 29.71,59.65 30.2,59.65 30.27,59.73 30.27,59.83 30.2,59.91 29.56,59.91 29.49,59.98 29.49,63.1 29.89,63.5 30.2,63.5 30.32,63.63 40.38,63.63 40.61,63.4 41.17,63.4
M_1_DQ56: length 21.1
  IN3 w0.06: v8(45.72,63.31) 45.62,63.41 45.29,63.41 45.2,63.32 42.99,63.32 42.92,63.25 41.91,63.25 41.7,63.45 41.56,63.45 ; 30.7,60.45 30.7,60.41 30.98,60.12 30.98,59.95 30.71,59.67 30.71,58.98 30.81,58.88 31.16,58.88 31.24,58.95 31.24,59.11 31.18,59.16 v8(31.01,59.16)
  IN3 w0.064: 41.56,63.45 41.48,63.45 40.69,64.24 33.37,64.24 33.32,64.19 33.32,64.11 33.42,64.01 33.42,63.92 33.34,63.84 33.19,63.84 33.02,64.01 32.92,64.01 32.36,63.45 32.36,63.3 32.28,63.23 32.14,63.23 30.79,61.88 30.79,61 30.7,60.91 30.7,60.45
M_1_DQ57: length 21.5
  IN3 w0.06: v8(30.51,58.66) 30.69,58.66 30.76,58.6 30.76,58.12 30.93,57.94 32.54,57.94 32.66,58.06 32.66,59.51 32.84,59.69 32.84,60.07 32.56,60.35 32.56,60.45 ; 43.38,61.77 43.7,61.77 44.26,62.34 45.84,62.34 45.92,62.26 46.08,62.26 46.2,62.38 46.79,62.38 46.85,62.32 v8(46.85,62.18)
  IN3 w0.064: 32.56,60.45 32.56,60.48 33.17,61.09 33.55,61.09 34.77,62.31 34.77,62.43 34.92,62.59 38.85,62.59 39.66,61.77 43.38,61.77
M_1_DQ58: length 20.1
  IN3 w0.06: 30.89,60.45 30.89,60.42 31.21,60.1 31.21,59.67 31.16,59.62 31.05,59.62 v8(31.01,59.66) ; 41.56,63.25 41.65,63.25 41.81,63.1 43.1,63.1 43.2,63.2 45.28,63.2 45.36,63.27 45.48,63.27 45.64,63.11 45.8,63.11 45.92,63.23 46.08,63.23 46.2,63.11 46.48,63.11 v8(46.57,63.03)
  IN3 w0.064: 41.56,63.25 41.25,63.25 41.17,63.32 41.17,63.49 40.63,64.03 33.8,64.03 33.42,63.65 32.83,63.65 32.55,63.37 32.55,63.17 32.41,63.04 32.22,63.04 31.72,62.54 31.72,62.38 31.66,62.32 31.5,62.32 31.01,61.83 31.01,61.12 31.06,61.07 31.06,60.95 30.89,60.78 30.89,60.45
M_1_DQ59: length 21.4
  IN3 w0.06: 30.51,60.45 30.51,60.25 30.58,60.17 30.71,60.17 30.78,60.1 30.78,59.97 30.71,59.89 30.5,59.89 30.43,59.82 30.43,59.74 v8(30.51,59.66) ; 41.56,63.65 41.89,63.65 41.96,63.58 41.96,63.47 42.03,63.4 42.13,63.4 42.2,63.47 42.2,63.58 42.27,63.65 42.36,63.65 42.44,63.58 42.44,63.45 42.49,63.4 42.8,63.4 42.87,63.48 45.16,63.48 45.22,63.53 45.78,63.53 45.86,63.45 46.01,63.45 46.1,63.53 46.46,63.53 46.56,63.43 46.56,63.32 46.48,63.23 46.36,63.23 v8(46.28,63.31)
  IN3 w0.064: 30.51,60.45 30.51,60.99 30.6,61.08 30.6,61.2 30.5,61.3 30.5,61.41 30.6,61.51 30.6,61.63 30.51,61.72 30.51,61.87 33.08,64.44 40.76,64.44 41.55,63.65 41.56,63.65
M_1_DQ60: length 21
  IN3 w0.06: 43.38,61.98 43.73,61.98 44.22,62.46 v8(46,62.46) ; 32.26,60.45 32.26,60.32 32.64,59.95 32.64,59.79 32.38,59.54 32.38,59.44 32.48,59.34 32.48,58.6 32.43,58.55 31.97,58.55 31.9,58.47 31.9,58.37 31.97,58.29 32.41,58.29 32.48,58.23 32.48,58.13 32.41,58.06 31.1,58.06 v8(31.01,58.15)
  IN3 w0.064: 32.26,60.45 33.12,61.32 33.5,61.32 34.55,62.36 34.55,62.67 34.68,62.81 38.9,62.81 39.46,62.24 39.61,62.24 39.66,62.2 39.66,62.05 39.73,61.97 39.84,61.97 39.91,62.05 39.91,62.2 39.96,62.24 40.1,62.24 40.37,61.98 43.38,61.98
M_1_DQ61: length 21.1
  IN3 w0.06: 41.56,63.91 41.67,63.81 42.44,63.81 42.59,63.65 46.51,63.65 v8(46.85,63.31) ; v8(30.51,59.16) 30.31,59.36 30.31,60.45
  IN3 w0.064: 41.56,63.91 40.83,64.64 33.02,64.64 30.31,61.94 30.31,60.45
M_1_DQ62: length 21
  IN3 w0.06: 32.03,60.45 32.03,60.1 32.28,59.84 32.28,59.72 32.18,59.62 32.04,59.62 31.96,59.53 31.96,59.42 32.04,59.34 32.23,59.34 32.28,59.29 32.28,58.8 32.18,58.7 31.85,58.7 31.75,58.6 31.75,58.37 31.65,58.27 31.18,58.27 31.01,58.44 v8(31.01,58.67) ; v8(46.85,62.75) 46.63,62.53 46.22,62.53 46.08,62.66 45.92,62.66 45.86,62.66 45.78,62.58 44.17,62.58 43.76,62.18 43.38,62.18
  IN3 w0.064: 32.03,60.45 32.03,60.49 33.06,61.52 33.42,61.52 34.36,62.45 34.36,62.91 34.44,63 38.98,63 39.54,62.43 40.18,62.43 40.43,62.18 43.38,62.18
M_1_DQ63: length 20.9
  IN3 w0.06: 43.38,61.57 43.66,61.57 44.31,62.22 45.78,62.22 45.88,62.12 46.22,62.12 v8(46.28,62.18) ; 32.86,57.91 32.74,57.79 30.3,57.79 30.2,57.89 30.2,58.06 30.3,58.16 v8(30.51,58.16)
  IN3 w0.064: 32.86,57.91 32.86,59.41 33.07,59.62 33.07,60.16 32.89,60.34 32.89,60.54 33.21,60.86 33.63,60.86 35.15,62.38 38.78,62.38 39.6,61.57 43.38,61.57
M_1_DQSN0: length 17.5
  IN4 w0.06: 45.39,54.76 45.39,54.78 45.4,54.79 45.4,55.19 45.92,55.7 45.92,56.72 v8(46,56.81) ; v8(36.01,56.16) 36.17,56.16 37.02,57.02 37.89,57.02 37.94,57.06 38.34,57.06 38.36,57.08 38.38,57.08
  IN4 w0.076: 38.38,57.08 38.57,57.08 39.42,56.22 39.42,55.93 40.38,54.97 41,54.97 41.2,54.78 41.2,53.8 41.27,53.72 42.08,53.72 42.16,53.8 42.16,54.09 42.33,54.26 42.63,54.26 42.8,54.09 42.8,53.8 42.87,53.72 43.05,53.72 43.13,53.8 43.13,54.22 43.29,54.38 43.6,54.38 43.76,54.22 43.76,53.47 43.84,53.39 44.01,53.39 44.09,53.47 44.09,54.17 44.26,54.33 45.3,54.33 45.39,54.42 45.39,54.76
M_1_DQSN1: length 22
  IN4 w0.06: 47.77,54.76 47.77,54.78 47.79,54.8 47.79,56.71 v8(47.7,56.81) ; v8(37.25,53.43) 37.37,53.43 37.61,53.66 37.99,53.66 38.34,53.32 38.38,53.32
  IN4 w0.076: 38.38,53.32 38.58,53.32 38.76,53.14 38.76,52.43 40.84,50.34 45.17,50.34 45.48,50.65 45.79,50.65 46.22,50.22 46.33,50.22 46.45,50.34 46.45,50.45 45.98,50.92 45.98,51.16 46.2,51.37 46.43,51.37 46.9,50.9 47.01,50.9 47.13,51.03 47.13,51.13 46.66,51.6 46.66,51.84 46.88,52.05 47.11,52.05 47.55,51.62 47.65,51.62 47.78,51.75 47.78,51.85 47.51,52.13 47.51,52.36 47.77,52.63 47.77,54.76
  BOTTOM w0.102: U24.D15 v8(37.25,53.43)
M_1_DQSN2: length 20.2
  IN3 w0.06: v8(36.01,55.16) 36.22,55.37 36.6,55.37 36.87,55.11 36.87,53.7 36.98,53.59 36.98,53.34 36.87,53.23 36.87,53.07 36.93,53.01 37.83,53.01 38.1,52.74 38.13,52.74 38.14,52.73 ; v8(47.98,58.79) 47.98,58.72 48.02,58.68 48.02,58.18 47.94,58.11 47.94,55.98 47.93,55.97
  IN3 w0.083: 38.14,52.73 38.47,52.41 45.29,52.41 46.49,53.61 46.49,53.69 46.35,53.83 46.35,54.07 46.58,54.3 46.82,54.3 46.98,54.13 47.09,54.13 47.23,54.27 47.23,54.38 47.06,54.54 47.06,54.78 47.17,54.89 47.17,55.2 47.93,55.96 47.93,55.97
M_1_DQSN3: length 16
  IN3 w0.06: v8(37.01,57.66) 37.11,57.56 37.23,57.56 37.3,57.62 37.3,57.85 37.44,57.99 37.8,57.99 37.97,57.82 38.24,57.82 38.26,57.84 38.27,57.84 ; v8(46,57.94) 46,57.85 45.86,57.71 45.86,57.44 44.55,56.14 44.37,56.14 44.29,56.05 44.26,56.05 44.26,56.04
  IN3 w0.083: 38.27,57.84 39.24,57.84 39.43,57.64 39.43,57.37 39.24,57.17 37.66,57.17 37.56,57.07 37.56,56.92 37.66,56.82 39.19,56.82 39.36,56.65 39.36,56.34 39.73,55.98 39.73,55.55 39.8,55.48 43.7,55.48 44.26,56.04
M_1_DQSN4: length 15.4
  IN3 w0.06: v8(46.28,61.62) 46.21,61.55 45.93,61.55 45.8,61.41 44.7,61.41 44.7,61.42 44.53,61.42 43.5,60.39 43.41,60.39 43.39,60.41 43.38,60.41 ; 35.1,60.45 35.09,60.44 35.09,60.42 34.67,59.99 34.67,59.69 34.46,59.49 34.29,59.49 34.13,59.33 34.13,59.25 33.73,58.85 33.73,58.44 v8(34.01,58.16)
  IN3 w0.083: 43.38,60.41 39.21,60.41 38.4,61.22 35.87,61.22 35.1,60.45
M_1_DQSN5: length 13.6
  IN4 w0.06: 42.14,60.21 42.15,60.22 42.15,60.25 42.25,60.35 42.57,60.35 43.27,61.05 v8(44.59,61.05) ; 35.86,60.35 35.84,60.34 35.82,60.34 35.75,60.27 35.75,59.58 35.51,59.34 v8(35.51,59.16)
  IN4 w0.076: 42.14,60.21 41.94,60.02 41.55,60.02 41.47,59.95 41.47,59.68 41.31,59.51 41.01,59.51 40.84,59.68 40.84,59.95 40.76,60.02 40.59,60.02 40.51,59.95 40.51,59.68 40.34,59.51 40.04,59.51 39.87,59.68 39.87,60.3 39.8,60.38 39.62,60.38 39.54,60.3 39.54,59.93 39.38,59.77 39.07,59.77 38.91,59.93 38.91,60.44 38.71,60.64 36.15,60.64 35.86,60.35
M_1_DQSN6: length 22.6
  IN4 w0.06: v8(33.01,58.16) 32.98,58.16 32.1,59.04 31.42,59.04 31.26,59.19 31.26,59.7 31.14,59.82 31.14,60.05 31.13,60.06 31.13,60.07 ; v8(44.27,62.99) 44.19,63.07 42.88,63.07 42.6,62.79 41.35,62.79 41.29,62.85 41.19,62.85 41.18,62.87 41.17,62.87
  IN4 w0.076: 41.17,62.87 40.38,62.87 40.14,63.11 33.68,63.11 33.39,62.82 33.19,62.82 32.92,63.1 30.72,63.1 30.02,62.4 30.02,61.41 30.18,61.24 30.65,61.24 30.73,61.16 30.73,60.99 30.65,60.91 30.18,60.91 30.02,60.75 30.02,60.44 30.18,60.27 31.02,60.27 31.13,60.17 31.13,60.07
M_1_DQSN7: length 21.7
  IN3 w0.06: 31.49,60.45 31.49,60.44 31.51,60.42 31.51,59.86 31.76,59.6 v8(31.76,59.41) ; v8(46,63.03) 45.88,62.91 45.6,62.91 45.52,62.83 43.99,62.83 43.81,62.65 43.41,62.65 43.39,62.67 43.38,62.67
  IN3 w0.083: 43.38,62.67 40.71,62.67 40.61,62.77 40.61,63.32 40.42,63.51 40.14,63.51 39.95,63.32 39.95,63.07 39.85,62.97 39.7,62.97 39.6,63.07 39.6,63.32 39.44,63.48 33.99,63.48 33.73,63.22 33.73,62.98 33.87,62.84 33.87,62.66 33.78,62.56 33.6,62.56 33.37,62.33 33.37,62.18 33.3,62.1 33.12,62.1 32.71,62.52 32.43,62.52 32.24,62.32 32.24,62.05 32.5,61.79 32.5,61.65 32.4,61.55 32.25,61.55 31.99,61.81 31.72,61.81 31.53,61.61 31.53,61.34 31.79,61.07 31.79,60.95 31.49,60.65 31.49,60.45
  BOTTOM w0.102: v8(31.76,59.41) 31.51,59.16 U24.R4
M_1_DQSP0: length 17.5
  IN4 w0.06: 38.38,56.92 38.37,56.92 38.35,56.94 37.99,56.94 37.94,56.9 37.07,56.9 36.47,56.3 36.47,56.2 v8(36.51,56.16) ; 45.54,54.76 45.54,54.78 45.52,54.8 45.52,55.14 46.04,55.65 46.04,56 46.1,56.06 46.1,56.21 46.04,56.27 46.04,56.56 46.12,56.64 46.2,56.64 46.28,56.56 v8(46.28,56.45)
  IN4 w0.076: 38.38,56.92 38.5,56.92 39.27,56.16 39.27,55.87 40.32,54.81 40.94,54.81 41.04,54.71 41.04,53.74 41.21,53.57 42.15,53.57 42.31,53.74 42.31,54.03 42.39,54.1 42.57,54.1 42.64,54.03 42.64,53.74 42.81,53.57 43.11,53.57 43.28,53.74 43.28,54.15 43.35,54.23 43.53,54.23 43.61,54.15 43.61,53.41 43.77,53.24 44.08,53.24 44.24,53.41 44.24,54.1 44.32,54.18 45.36,54.18 45.54,54.36 45.54,54.76
M_1_DQSP1: length 22.1
  IN4 w0.06: v8(37.75,53.43) 37.75,53.46 37.84,53.54 37.94,53.54 38.3,53.19 38.34,53.19 38.37,53.16 38.38,53.16 ; 47.93,54.76 47.93,54.78 47.91,54.8 47.91,57.02 v8(47.98,57.09)
  IN4 w0.076: 38.38,53.16 38.52,53.16 38.6,53.08 38.6,52.36 40.78,50.19 45.23,50.19 45.54,50.5 45.72,50.5 46.15,50.06 46.39,50.06 46.6,50.28 46.6,50.51 46.13,50.98 46.13,51.09 46.26,51.22 46.37,51.22 46.84,50.75 47.07,50.75 47.29,50.96 47.29,51.2 46.82,51.67 46.82,51.78 46.94,51.9 47.05,51.9 47.48,51.47 47.72,51.47 47.93,51.68 47.93,51.92 47.66,52.19 47.66,52.3 47.93,52.57 47.93,54.76
  BOTTOM w0.102: U24.D16 v8(37.75,53.43)
M_1_DQSP2: length 20.2
  IN3 w0.06: 38.03,52.62 38.02,52.63 38.02,52.66 37.79,52.89 36.88,52.89 36.75,53.02 36.75,53.28 36.86,53.39 36.86,53.54 36.75,53.65 36.75,54.89 36.69,54.94 36.32,54.94 36.24,55.02 36.24,55.14 36.32,55.22 36.45,55.22 v8(36.51,55.16) ; v8(48.26,58.5) 48.19,58.5 48.14,58.45 48.14,58.13 48.06,58.06 48.06,55.91
  IN3 w0.083: 48.06,55.91 48.06,55.87 47.33,55.13 47.33,54.83 47.22,54.72 47.22,54.61 47.39,54.44 47.39,54.2 47.16,53.97 46.92,53.97 46.75,54.14 46.64,54.14 46.51,54 46.51,53.9 46.65,53.76 46.65,53.54 45.36,52.25 38.4,52.25 38.03,52.62
M_1_DQSP3: length 16
  IN3 w0.06: 44.37,55.93 44.37,55.96 44.42,56.02 44.6,56.02 45.98,57.39 45.98,57.63 46.22,57.88 46.22,58.16 v8(46.28,58.22) ; v8(37.51,57.66) 37.44,57.73 37.44,57.81 37.49,57.87 37.75,57.87 37.92,57.7 38.24,57.7 38.26,57.68 38.27,57.68
  IN3 w0.083: 38.27,57.68 39.17,57.68 39.27,57.58 39.27,57.43 39.17,57.33 37.6,57.33 37.4,57.13 37.4,56.86 37.6,56.66 39.12,56.66 39.2,56.59 39.2,56.28 39.57,55.91 39.57,55.49 39.73,55.32 43.76,55.32 44.37,55.93
M_1_DQSP4: length 15.4
  IN3 w0.06: v8(46,61.33) 45.98,61.33 45.94,61.3 44.65,61.3 44.65,61.3 44.58,61.3 43.55,60.27 43.41,60.27 43.39,60.25 43.38,60.25 ; 35.21,60.34 35.2,60.33 35.17,60.33 34.79,59.94 34.79,59.64 34.51,59.37 34.34,59.37 34.25,59.28 34.25,59.2 34.06,59.01 34.06,58.93 34.16,58.83 34.24,58.83 34.29,58.78 34.29,58.42 34.24,58.37 33.98,58.37 33.85,58.49 33.85,58.65 33.91,58.7 33.97,58.7 v8(34.01,58.66)
  IN3 w0.083: 35.21,60.34 35.93,61.06 38.33,61.06 39.14,60.25 43.38,60.25
M_1_DQSP5: length 13.6
  IN4 w0.06: v8(35.51,59.66) 35.63,59.79 35.63,60.32 35.74,60.42 35.74,60.44 35.75,60.45 ; v8(44.87,61.33) 44.79,61.25 44.48,61.25 44.4,61.17 43.22,61.17 42.52,60.47 42.2,60.47 42.06,60.33 42.04,60.33 42.03,60.32
  IN4 w0.076: 42.03,60.32 41.88,60.17 41.49,60.17 41.32,60.01 41.32,59.74 41.25,59.67 41.07,59.67 40.99,59.74 40.99,60.01 40.83,60.17 40.52,60.17 40.36,60.01 40.36,59.74 40.28,59.67 40.1,59.67 40.03,59.74 40.03,60.36 39.86,60.53 39.56,60.53 39.39,60.36 39.39,60 39.32,59.92 39.14,59.92 39.06,60 39.06,60.5 38.78,60.79 36.08,60.79 35.75,60.45
M_1_DQSP6: length 22.6
  IN4 w0.06: 31.28,60.07 31.28,60.06 31.26,60.04 31.26,59.87 31.38,59.75 31.38,59.24 31.47,59.16 32.15,59.16 32.92,58.4 33.14,58.4 33.22,58.47 33.22,58.57 33.13,58.66 v8(33.01,58.66) ; 41.17,62.71 41.19,62.71 41.2,62.73 41.24,62.73 41.3,62.67 42.65,62.67 42.93,62.95 43.93,62.95 44.01,62.87 44.01,62.79 43.97,62.75 v8(43.95,62.75)
  IN4 w0.076: 41.17,62.71 40.32,62.71 40.07,62.96 33.75,62.96 33.45,62.67 33.13,62.67 32.85,62.94 30.78,62.94 30.17,62.33 30.17,61.47 30.25,61.39 30.72,61.39 30.88,61.23 30.88,60.92 30.72,60.76 30.25,60.76 30.17,60.68 30.17,60.5 30.25,60.43 31.09,60.43 31.28,60.23 31.28,60.07
M_1_DQSP7: length 21.7
  IN3 w0.06: v8(46.28,62.75) 46.38,62.84 46.38,62.89 46.3,62.97 46.22,62.97 46.04,62.79 45.65,62.79 45.57,62.71 44.04,62.71 43.86,62.53 43.41,62.53 43.39,62.51 43.38,62.51 ; 31.65,60.45 31.65,60.39 31.63,60.37 31.63,59.91 31.67,59.87 31.72,59.87 v8(31.76,59.91)
  IN3 w0.083: 43.38,62.51 40.65,62.51 40.45,62.71 40.45,63.25 40.35,63.35 40.21,63.35 40.11,63.25 40.11,63.01 39.92,62.81 39.63,62.81 39.44,63.01 39.44,63.26 39.37,63.32 34.05,63.32 33.89,63.16 33.89,63.04 34.03,62.9 34.03,62.59 33.84,62.4 33.67,62.4 33.53,62.27 33.53,62.11 33.37,61.95 33.05,61.95 32.64,62.36 32.5,62.36 32.4,62.26 32.4,62.12 32.66,61.86 32.66,61.58 32.46,61.39 32.19,61.39 31.93,61.65 31.79,61.65 31.68,61.55 31.68,61.4 31.95,61.14 31.95,60.89 31.65,60.58 31.65,60.45
  BOTTOM w0.102: v8(31.76,59.91) 31.73,59.88 31.73,59.72 31.66,59.66 U24.T4
M_1_ODT0: length 36.8
  IN2 w0.064: v12(35.77,56.29) 35.91,56.29 36.01,56.19 36.01,55.78 35.91,55.68 34.52,55.68 34.41,55.78 34.41,55.93 34.52,56.03 35.21,56.03 35.3,56.13 35.3,56.27 35.21,56.36 34.49,56.36 34.39,56.47 34.39,56.61 34.49,56.71 35.44,56.71 35.53,56.8 35.53,56.93 35.44,57.02 34.46,57.02 34.39,57.1 34.39,57.27 34.46,57.34 35.4,57.34 35.48,57.42 35.48,57.58 35.4,57.66 34.46,57.66 34.39,57.74 34.39,57.9 34.46,57.98 35.4,57.98 35.48,58.05 35.48,58.22 35.4,58.29 34.46,58.29 34.39,58.37 34.39,58.54 34.46,58.61 35.4,58.61 35.48,58.69 35.48,58.85 35.4,58.93 34.46,58.93 34.39,59.01 34.39,59.17 34.46,59.25 35.43,59.25 35.51,59.32 35.51,59.49 35.43,59.56 34.46,59.56 34.39,59.64 34.39,59.81 34.46,59.88 35.43,59.88 35.51,59.96 35.51,60.12 35.43,60.2 34.46,60.2 34.39,60.28 34.39,60.44 34.46,60.52 35.4,60.52 35.48,60.59 35.48,60.78 35.58,60.89 40,60.89 40.1,60.78 40.1,56.97 40.2,56.87 v12(40.84,56.87)
  IN3 w0.06: v8(35.77,55.89) v12(35.77,56.29)
  IN3 w0.064: v12(40.84,56.87) v11(41.25,56.87)
  IN4 w0.064: v11(41.25,56.87) 41.6,56.87 42.14,56.34 44.07,56.34 44.12,56.39 44.42,56.39 44.52,56.29 44.65,56.29 44.81,56.45 v8(45.15,56.45)
  BOTTOM w0.114: U24.H13 36.01,55.66 v8(35.77,55.89)
M_1_ODT2: length 36.8
  IN2 w0.064: v12(33.37,59.67) 33.37,60.05 33.47,60.15 33.91,60.15 33.98,60.22 33.98,62.94 34.06,63.02 34.22,63.02 34.3,62.94 34.3,62.13 34.38,62.05 34.54,62.05 34.62,62.13 34.62,62.94 34.69,63.02 34.86,63.02 34.93,62.94 34.93,62.16 35.04,62.05 35.2,62.05 35.25,62.1 35.25,62.94 35.33,63.02 35.49,63.02 35.57,62.94 35.57,62.18 35.65,62.1 35.81,62.1 35.89,62.18 35.89,62.94 35.96,63.02 36.13,63.02 36.2,62.94 36.2,62.18 36.28,62.1 36.45,62.1 36.52,62.18 36.52,62.94 36.6,63.02 36.76,63.02 36.84,62.94 36.84,62.21 36.92,62.13 37.08,62.13 37.16,62.21 37.16,62.94 37.23,63.02 37.4,63.02 37.47,62.94 37.47,62.18 37.55,62.1 37.72,62.1 37.79,62.18 37.79,62.94 37.87,63.02 38.03,63.02 38.11,62.94 38.11,62.18 38.19,62.1 38.35,62.1 38.43,62.18 38.43,62.94 38.5,63.02 38.67,63.02 38.74,62.94 38.74,62.21 38.82,62.13 38.99,62.13 39.06,62.21 39.06,62.94 39.14,63.02 39.3,63.02 39.38,62.94 39.38,62.21 39.46,62.13 39.6,62.13 39.67,62.21 39.67,62.92 39.75,62.99 39.9,62.99 39.98,62.92 39.98,62.21 40.05,62.13 40.54,62.13 40.64,62.03 40.64,58.32 41.17,57.79 41.17,57.56 41.68,57.05 v12(41.68,56.82)
  IN3 w0.06: v12(33.37,59.67) 33.3,59.59 33.3,58.37 v8(33.51,58.16)
  IN3 w0.064: v11(42.08,56.82) v12(41.68,56.82)
  IN4 w0.064: v8(44.87,56.81) 44.56,56.81 44.37,56.62 43.86,56.62 43.79,56.54 42.36,56.54 v11(42.08,56.82)
MAG_DRDY: length 127.8
  IN2 w0.064: v9(175.03,82.05) 175.03,76.23 174.27,75.46 168.49,75.46 167.79,74.76 167.79,73.06 167.66,72.93 148.85,72.93 144.47,68.56 130.76,68.56 127.91,65.71 127.91,57.81 126.74,56.64 125.07,56.64 123.15,54.73 123.15,40.4 122.27,39.52 103.53,39.52 102.64,38.63 102.64,38 102.26,37.62 100.2,37.62 99.26,36.68 94.13,36.68 93.24,37.57 93.24,40.82 v5(91.26,42.8)
  BOTTOM w0.114: v9(175.03,82.05) 175,82.08 U35.9
MCLK: length 5.7
  IN3 w0.064: v1(111.02,68.77) 110.95,68.84 110.95,69.82 111.24,70.11 112.75,70.11 113.24,70.6 v1(114.4,70.6)
  BOTTOM w0.114: v1(111.02,68.77) R351.2
MCSI_1_CLK_DN: length 93.1
  IN2 w0.07: v12(58.62,67.18) 58.62,67.31 58.78,67.47 59.76,67.47 60.09,67.8 61.33,67.8 62.48,66.65 62.48,61.25 62.73,60.99 62.73,60.38 63.39,59.72 63.39,57.89 59.35,53.84 55.46,53.84 54.48,52.86 50.27,52.86 50.04,52.62 49.15,52.62 45.58,49.06 44.9,49.06 41.25,45.41 21.14,45.41 19.04,47.51 19.04,51.2 18.03,52.22 17.8,52.22 15.5,54.51 14.38,54.51 13.46,55.43 13.46,61.86 12.79,62.54 10.28,62.54 9.72,63.1 9.72,63.7 9.82,63.8 9.96,63.8 10.34,63.42 v9(10.34,63.26)
  IN3 w0.06: v8(57.04,64.45) 57.04,64.73 56.79,64.97 56.79,65.05 57.31,65.57 57.48,65.57 57.96,66.05 57.96,67.24 58.26,67.54 58.37,67.54 58.62,67.29 v12(58.62,67.18)
  BOTTOM w0.076: U15.1 10.97,63.38 10.66,63.68 10.59,63.68 10.34,63.43 v9(10.34,63.26)
MCSI_1_CLK_DP: length 93.1
  IN2 w0.07: v12(58.59,67.74) 58.7,67.64 59.69,67.64 60.02,67.97 61.41,67.97 62.65,66.73 62.65,61.32 62.91,61.06 62.91,60.45 63.56,59.79 63.56,57.82 59.42,53.67 55.54,53.67 54.55,52.69 50.34,52.69 50.11,52.45 49.22,52.45 45.65,48.88 44.97,48.88 41.32,45.24 21.07,45.24 18.87,47.44 18.87,51.13 17.96,52.05 17.73,52.05 15.43,54.34 14.31,54.34 13.29,55.36 13.29,61.79 12.72,62.36 10.21,62.36 9.55,63.02 9.55,63.78 9.75,63.97 v9(10.34,63.97)
  IN3 w0.06: v12(58.59,67.74) 58.51,67.66 58.21,67.66 57.84,67.29 57.84,66.1 57.43,65.69 57.26,65.69 56.67,65.1 56.67,64.92 56.75,64.84 v8(56.75,64.73)
  BOTTOM w0.076: U15.2 10.82,63.93 10.72,63.83 10.47,63.83 v9(10.34,63.97)
MCSI_1_DATA0_DN: length 96.1
  IN2 w0.07: v4(14.83,55.98) 14.68,55.98 14.52,55.82 14.52,55.66 14.65,55.53 15.4,55.53 15.6,55.72 15.6,56.77 15.52,56.85 14.4,56.85 14.22,57.03 14.22,57.47 14.4,57.64 15.52,57.64 15.6,57.72 15.6,58.02 15.52,58.09 14.4,58.09 14.22,58.27 14.22,58.71 14.4,58.89 15.52,58.89 15.6,58.96 15.6,59.26 15.52,59.34 14.4,59.34 14.22,59.51 14.22,59.95 14.4,60.13 15.74,60.13 16.18,60.57 17.27,60.57 17.37,60.67 17.37,60.92 17.27,61.02 16.28,61.02 16.11,61.2 16.11,61.72 16.28,61.89 18,61.89 18.25,61.64 18.25,55.95 18.64,55.57 20.04,55.57 20.34,55.27 20.34,47.98 21.63,46.68 40.74,46.68 47.96,53.89 49.48,53.89 50.01,54.43 54.26,54.43 54.95,55.12 57.72,55.12 61.4,58.8 61.4,60.5 61.21,60.69 61.21,61.98 60.18,63.01 60.18,66 59.93,66.24 59.54,66.24 59.46,66.32 59.36,66.32 59.23,66.19 v12(59.23,66.12)
  IN3 w0.06: v12(59.23,66.12) 59.23,66.19 59.03,66.4 58.92,66.4 58.84,66.31 58.84,66.09 58.04,65.29 58.04,64.35 57.86,64.17 57.57,64.17 57.53,64.13 57.53,63.96 v8(57.6,63.88)
  IN3 w0.07: v1(14.78,56.93) 14.57,56.93 14.44,56.8 14.44,56.25 14.7,55.98 v4(14.83,55.98)
MCSI_1_DATA0_DP: length 96.2
  IN2 w0.07: v12(59.23,66.63) 59.36,66.49 59.53,66.49 59.61,66.42 60,66.42 60.35,66.07 60.35,63.08 61.38,62.05 61.38,60.76 61.57,60.57 61.57,58.73 57.79,54.95 55.02,54.95 54.33,54.26 50.09,54.26 49.55,53.72 48.03,53.72 40.81,46.51 21.56,46.51 20.16,47.91 20.16,55.2 19.97,55.4 18.56,55.4 18.08,55.88 18.08,61.57 17.93,61.72 16.35,61.72 16.28,61.65 16.28,61.27 16.35,61.2 17.34,61.2 17.54,60.99 17.54,60.6 17.34,60.4 16.25,60.4 15.81,59.96 14.47,59.96 14.39,59.88 14.39,59.59 14.47,59.51 15.59,59.51 15.77,59.33 15.77,58.89 15.59,58.72 14.47,58.72 14.39,58.64 14.39,58.34 14.47,58.26 15.59,58.26 15.77,58.09 15.77,57.65 15.59,57.47 14.47,57.47 14.39,57.39 14.39,57.1 14.47,57.02 15.59,57.02 15.77,56.84 15.77,55.65 15.47,55.35 14.58,55.35 14.35,55.59 14.35,55.83 v4(14.2,55.98)
  IN3 w0.06: v8(57.32,64.16) 57.39,64.16 57.52,64.29 57.81,64.29 57.92,64.4 57.92,65.34 58.72,66.14 58.72,66.36 58.87,66.52 59.12,66.52 v12(59.23,66.63)
  IN3 w0.07: v1(14.23,56.93) 14.27,56.89 14.27,56.05 v4(14.2,55.98)
MCSI_1_DATA1_DN: length 94.6
  IN2 w0.07: v12(60.22,67.39) 60.4,67.2 60.6,67.2 60.82,66.98 61.52,66.98 62.02,66.48 62.02,61 62.2,60.82 62.2,57.34 59.18,54.31 55.29,54.31 54.6,53.62 50.38,53.62 49.85,53.09 48.29,53.09 41.07,45.87 21.32,45.87 19.5,47.69 19.5,52.16 19.43,52.24 18.64,52.24 18.44,52.44 18.44,52.83 18.64,53.03 19.43,53.03 19.5,53.11 19.5,53.41 19.43,53.48 17.98,53.48 17.78,53.69 17.78,54.08 17.98,54.28 19.44,54.28 19.54,54.38 19.54,54.66 19.44,54.76 17.68,54.76 17.42,55.02 17.42,55.89 17.34,55.97 17.09,55.97 16.91,56.14 16.91,56.58 17.09,56.76 17.34,56.76 17.42,56.84 17.42,57.14 17.34,57.21 17.09,57.21 16.91,57.39 16.91,57.83 17.09,58.01 17.34,58.01 17.42,58.08 17.42,58.38 17.34,58.46 17.09,58.46 16.91,58.63 16.91,59.07 17.09,59.25 17.34,59.25 17.42,59.33 17.42,59.67 17.34,59.74 16.5,59.74 16.42,59.67 16.42,55.09 16.48,55.03 16.7,55.03 16.94,54.79 16.94,54.43 v4(17.09,54.28)
  IN3 w0.06: v8(57.04,65.01) 57.23,65.01 58.4,66.18 58.4,66.45 59.13,67.18 60.01,67.18 v12(60.22,67.39)
  IN3 w0.07: v4(17.09,54.28) 17,54.38 17,54.86 17.09,54.95 17.09,56.49 16.98,56.6 16.98,56.85 v1(17.06,56.93)
MCSI_1_DATA1_DP: length 94.6
  IN2 w0.07: v4(16.51,54.28) 16.77,54.54 16.77,54.72 16.63,54.86 16.41,54.86 16.25,55.02 16.25,59.74 16.43,59.91 17.42,59.91 17.59,59.74 17.59,59.26 17.42,59.08 17.16,59.08 17.08,59 17.08,58.7 17.16,58.63 17.42,58.63 17.59,58.45 17.59,58.01 17.42,57.83 17.16,57.83 17.08,57.76 17.08,57.46 17.16,57.38 17.42,57.38 17.59,57.21 17.59,56.77 17.42,56.59 17.16,56.59 17.08,56.51 17.08,56.22 17.16,56.14 17.42,56.14 17.59,55.96 17.59,55.09 17.75,54.94 19.51,54.94 19.71,54.73 19.71,54.31 19.51,54.11 18.06,54.11 17.95,54 17.95,53.76 18.06,53.65 19.5,53.65 19.68,53.48 19.68,53.04 19.5,52.86 18.71,52.86 18.61,52.76 18.61,52.51 18.71,52.41 19.5,52.41 19.68,52.23 19.68,47.76 21.39,46.05 41,46.05 48.22,53.27 49.78,53.27 50.31,53.79 54.52,53.79 55.22,54.48 59.11,54.48 62.03,57.41 62.03,60.75 61.85,60.93 61.85,66.41 61.45,66.8 60.75,66.8 60.58,66.98 60.52,67.03 60.37,67.03 v12(60.22,66.88)
  IN3 w0.06: v12(60.22,66.88) 60.04,67.06 59.18,67.06 58.52,66.4 58.52,66.13 57.32,64.93 v8(57.32,64.73)
  IN3 w0.07: v1(16.51,56.93) 16.74,56.93 16.81,56.87 16.81,56.53 16.92,56.41 16.92,55.02 16.82,54.93 16.82,54.54 16.57,54.28 v4(16.51,54.28)
MCSI_2_CLK_DN: length 80.4
  IN2 w0.07: v12(62.35,69.11) 62.59,69.35 62.96,69.35 64.12,68.19 64.12,60.79 65.63,59.28 65.63,58.33 59.44,52.14 55.58,52.14 55.02,51.58 51.82,51.58 47.45,47.21 44.86,47.21 41.78,44.14 20.48,44.14 19.35,45.26 15.71,45.26 15.05,45.92 15.05,46.14 v4(15.29,46.38)
  IN3 w0.07: v12(62.35,69.11) 62.12,69.35 61.77,69.35 61.55,69.58 60.16,69.58 60.06,69.47 58.64,69.47 56.92,67.75 56.92,67.32 56.75,67.16 v8(56.75,66.99) ; v1(13.73,48.18) 13.73,47.99 13.91,47.81 14.25,47.81 15.05,47.01 15.05,46.61 v4(15.29,46.38)
MCSI_2_CLK_DP: length 80.9
  IN2 w0.07: v4(14.65,46.38) 14.88,46.14 14.88,45.85 15.64,45.09 19.28,45.09 20.4,43.97 41.86,43.97 44.93,47.04 47.52,47.04 51.89,51.41 55.09,51.41 55.65,51.97 59.52,51.97 65.8,58.26 65.8,59.35 64.29,60.87 64.29,68.26 63.03,69.52 62.58,69.52 v4(62.38,69.72)
  IN3 w0.07: v4(14.65,46.38) 14.88,46.61 14.88,46.94 14.18,47.64 13.74,47.64 v1(13.73,47.63) ; v4(62.38,69.72) 62.18,69.52 61.84,69.52 61.62,69.75 60.09,69.75 59.99,69.64 58.56,69.64 56.75,67.82 56.75,67.39 56.63,67.27 v8(56.47,67.27)
MCSI_2_DATA_DN: length 82.2
  IN2 w0.07: v12(59.05,68.02) 59.05,68.1 59.31,68.36 59.72,68.36 59.81,68.45 62.57,68.45 63.49,67.53 63.49,60.54 64.87,59.16 64.87,58.45 59.64,53.21 55.74,53.21 54.74,52.22 51.06,52.22 50.83,51.99 49.55,51.99 45.75,48.19 44.92,48.19 41.51,44.78 20.74,44.78 18.39,47.13 18.39,50.69 18.23,50.85 16.56,50.85 16.36,50.65 16.36,49.56 16.56,49.36 17.5,49.36 17.57,49.29 17.57,48.02 17.48,47.92 17.3,47.92 17.11,48.11 v4(17.11,48.19)
  IN3 w0.06: v8(57.6,66.14) 57.6,67.47 58.42,68.28 58.92,68.28 59.05,68.16 v12(59.05,68.02)
  IN3 w0.07: v1(16.4,48.18) 16.68,47.9 16.89,47.9 17.11,48.13 v4(17.11,48.19)
MCSI_2_DATA_DP: length 82.2
  IN2 w0.07: v4(17.11,47.63) 17.24,47.75 17.55,47.75 17.74,47.95 17.74,49.36 17.57,49.53 16.63,49.53 16.53,49.63 16.53,50.58 16.63,50.68 18.16,50.68 18.21,50.62 18.21,47.06 20.67,44.6 41.58,44.6 44.99,48.02 45.82,48.02 49.62,51.82 50.9,51.82 51.13,52.05 54.81,52.05 55.81,53.04 59.71,53.04 65.04,58.37 65.04,59.23 63.67,60.61 63.67,67.6 62.64,68.63 59.74,68.63 59.65,68.53 59.1,68.53 v12(59.05,68.58)
  IN3 w0.06: v8(57.32,66.43) 57.33,66.43 57.48,66.58 57.48,67.52 58.37,68.4 58.87,68.4 v12(59.05,68.58)
  IN3 w0.07: v1(16.4,47.63) 16.49,47.73 17.01,47.73 v4(17.11,47.63)
MCSI_COMP: length 2.2
  IN2 w0.114: v12(55.5,65.12) 56.96,65.12 v5(57.15,65.3)
  IN3 w0.305: v12(55.5,65.12) v1(55.92,65.12)
MDSI_A0_DN: length 46.4
  IN2 w0.07: v4(68.88,65.74) 68.7,65.55 68.7,65.39 68.93,65.16 68.93,64.8 70.04,63.69 70.04,62.17 69.75,61.88 69.75,60.34 68.86,59.45 68.86,57.79 64.14,53.07 64.14,52.22 61.35,49.44 56.72,49.44 55.52,48.24 55.52,47.32 55.34,47.14 54.76,47.14 54.63,47.02 54.63,46.75 54.7,46.68 55.67,46.68 55.87,46.48 55.87,46.08 55.67,45.88 54.75,45.88 54.63,45.76 54.63,44.86 54.76,44.73 54.96,44.73 55.17,44.53 v4(55.17,43.77)
  IN3 w0.06: 59.46,64.09 59.43,64.12 59.29,64.12 59.11,63.95 58.8,63.95 v8(58.73,63.88)
  IN3 w0.07: v4(55.17,43.77) 55.07,43.86 55.07,44.07 v1(55.22,44.22) ; v4(68.88,65.74) 68.7,65.55 68.7,65.22 68.51,65.03 68.12,65.03 67.9,65.25 63.12,65.25 62.09,64.23 60.48,64.23 60.34,64.09 59.46,64.09
