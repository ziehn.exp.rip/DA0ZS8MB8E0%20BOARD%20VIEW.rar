# Allegro board da0ee6mbad0-d-susan-165XL-0828.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
MDSI_A0_DN_C: length 4
  BOTTOM w0.076: L13.3 55.29,41.75 55,41.47 55,39.27 55.25,39.02 CN9.28
MDSI_A0_DP: length 46.4
  IN2 w0.07: v4(68.32,65.74) 68.53,65.53 68.53,65.32 68.76,65.09 68.76,64.73 69.87,63.61 69.87,62.25 69.57,61.95 69.57,60.41 68.68,59.53 68.68,57.86 63.96,53.14 63.96,52.29 61.28,49.61 56.65,49.61 55.35,48.31 55.35,47.39 55.27,47.32 54.69,47.32 54.46,47.09 54.46,46.68 54.63,46.51 55.6,46.51 55.7,46.41 55.7,46.15 55.6,46.05 54.68,46.05 54.46,45.83 54.46,44.79 54.69,44.56 54.89,44.56 54.99,44.46 54.99,44.1 54.66,43.77 v4(54.61,43.77)
  IN3 w0.06: 59.46,64.26 59.43,64.24 59.24,64.24 59.13,64.13 59.05,64.13 v8(59.02,64.16)
  IN3 w0.07: 59.46,64.26 60.27,64.26 60.41,64.4 62.02,64.4 63.04,65.43 67.97,65.43 68.2,65.2 68.44,65.2 68.53,65.29 68.53,65.53 v4(68.32,65.74) ; v4(54.61,43.77) 54.68,43.77 54.94,44.02 54.94,44.15 54.86,44.22 v1(54.56,44.22)
MDSI_A0_DP_C: length 4
  BOTTOM w0.076: CN9.27 54.65,39.07 54.85,39.27 54.85,41.46 54.49,41.83 L13.2
MDSI_A1_DN: length 47
  IN2 w0.07: v4(68.68,63.25) 68.47,63.04 68.47,60.83 67.61,59.97 67.61,58.3 62,52.69 62,51.84 60.86,50.71 56.2,50.71 52.39,46.89 51.43,46.89 51.33,46.79 51.33,46.53 51.43,46.43 52.82,46.43 53.03,46.23 53.03,45.83 52.82,45.63 51.46,45.63 51.36,45.52 51.36,45.26 51.46,45.16 52.67,45.16 52.87,44.96 52.87,44.55 52.67,44.35 51.7,44.35 51.41,44.06 51.41,43.94 v4(51.61,43.74)
  IN3 w0.07: v8(59.38,63.88) 59.48,63.77 62.43,63.77 62.97,64.3 63.59,64.3 64.08,64.8 67.64,64.8 68.44,64 68.44,63.48 v4(68.68,63.25) ; v4(51.61,43.74) 51.43,43.92 51.43,44.12 51.53,44.22 v1(51.66,44.22)
MDSI_A1_DN_C: length 4
  BOTTOM w0.076: CN9.22 51.65,39.14 51.41,39.39 51.41,41.5 51.73,41.83 L11.3
MDSI_A1_DP: length 47.1
  IN2 w0.07: v4(68.07,63.25) 68.3,63.02 68.3,60.9 67.44,60.04 67.44,58.37 61.83,52.76 61.83,51.91 60.79,50.88 56.13,50.88 52.31,47.06 51.36,47.06 51.16,46.86 51.16,46.46 51.36,46.26 52.75,46.26 52.85,46.16 52.85,45.9 52.75,45.8 51.39,45.8 51.18,45.6 51.18,45.19 51.39,44.99 52.6,44.99 52.7,44.89 52.7,44.62 52.6,44.52 51.63,44.52 51.23,44.13 51.23,43.92 v4(51.05,43.74)
  IN3 w0.07: v4(68.07,63.25) 68.27,63.45 68.27,63.92 67.57,64.63 64.15,64.63 63.66,64.13 63.04,64.13 62.51,63.6 59.33,63.6 59.3,63.63 v8(59.05,63.63) ; v4(51.05,43.74) 51.25,43.94 51.25,44.15 51.18,44.22 v1(51,44.22)
MDSI_A1_DP_C: length 4
  BOTTOM w0.076: CN9.21 51.05,39.13 51.25,39.33 51.25,41.51 50.93,41.83 L11.2
MDSI_A2_DN: length 46.6
  IN2 w0.07: v4(66.44,67.24) 66.23,67.03 66.23,65.97 67.55,64.65 67.55,60.83 66.99,60.26 66.99,58.56 59.77,51.34 55.93,51.34 52.12,47.53 50.94,47.53 50.03,46.62 50.03,46.48 50.14,46.38 50.56,46.38 50.76,46.17 50.76,45.77 50.56,45.57 50.14,45.57 50.03,45.47 50.03,45.21 50.14,45.11 50.62,45.11 50.82,44.9 50.82,44.51 50.62,44.31 49.95,44.31 49.83,44.18 v4(49.83,43.77)
  IN3 w0.06: v8(58.45,64.73) 58.52,64.79 58.85,64.79 59.01,64.96 59.18,64.96 59.2,64.93
  IN3 w0.07: v1(49.88,44.22) 49.83,44.22 49.72,44.12 49.72,43.87 v4(49.83,43.77) ; v4(66.44,67.24) 66.28,67.08 66.28,66.82 66.06,66.6 62.57,66.6 61.78,65.81 60.74,65.81 59.86,64.93 59.2,64.93
MDSI_A2_DN_C: length 4
  BOTTOM w0.076: L10.3 49.95,41.91 49.63,41.58 49.63,39.19 49.85,38.97 CN9.19
MDSI_A2_DP: length 46.6
  IN2 w0.07: v4(49.27,43.77) 49.32,43.77 49.66,44.1 49.66,44.25 49.88,44.48 50.55,44.48 50.65,44.58 50.65,44.83 50.55,44.93 50.07,44.93 49.86,45.14 49.86,45.54 50.07,45.74 50.49,45.74 50.59,45.84 50.59,46.1 50.49,46.2 50.07,46.2 49.86,46.41 49.86,46.69 50.87,47.7 52.05,47.7 55.86,51.51 59.7,51.51 66.82,58.63 66.82,60.33 67.38,60.9 67.38,64.58 66.06,65.9 66.06,67.03 v4(65.86,67.24)
  IN3 w0.06: 59.2,65.1 59.18,65.08 58.96,65.08 58.83,64.95 58.77,64.95 58.73,64.98 v8(58.73,65.01)
  IN3 w0.07: v4(49.27,43.77) 49.32,43.77 49.55,43.99 49.55,44.16 49.49,44.22 v1(49.22,44.22) ; v4(65.86,67.24) 66.11,66.98 66.11,66.89 65.99,66.77 62.5,66.77 61.71,65.98 60.67,65.98 59.79,65.1 59.2,65.1
MDSI_A2_DP_C: length 4
  BOTTOM w0.076: L10.2 49.15,41.83 49.47,41.51 49.47,39.14 49.25,38.92 CN9.18
MDSI_A3_DN: length 44.5
  IN2 w0.07: v4(56.97,43.77) 56.78,43.95 56.78,44.73 56.54,44.97 56.54,48.36 56.98,48.8 61.61,48.8 64.79,51.98 64.79,52.83 69.54,57.58 69.54,59.25 70.38,60.1 70.38,61.63 70.68,61.93 70.68,63.97 69.81,64.83 69.81,65.27 v4(70.08,65.53)
  IN3 w0.07: v1(56.99,44.22) 56.84,44.22 56.76,44.15 56.76,43.97 v4(56.97,43.77) ; v8(59.05,64.69) 59.13,64.61 59.27,64.61 59.33,64.67 59.98,64.67 60.33,65.03 61.65,65.03 62.71,66.09 67.44,66.09 68.18,66.82 69.21,66.82 69.84,66.19 69.84,65.77 v4(70.08,65.53)
MDSI_A3_DN_C: length 4
  BOTTOM w0.076: CN9.31 57.05,38.88 56.78,39.15 56.78,41.54 57.06,41.83 L14.3
MDSI_A3_DP: length 44.4
  IN2 w0.07: v4(69.47,65.53) 69.64,65.36 69.64,64.76 70.51,63.89 70.51,62 70.21,61.7 70.21,60.17 69.36,59.32 69.36,57.65 64.62,52.9 64.62,52.05 61.54,48.97 56.9,48.97 56.37,48.43 56.37,44.9 56.61,44.65 56.61,43.97 v4(56.41,43.77)
  IN3 w0.07: v4(56.41,43.77) 56.59,43.94 56.59,44.15 56.51,44.22 v1(56.33,44.22) ; v8(58.73,64.44) 58.94,64.44 58.94,64.44 59.34,64.44 59.4,64.5 60.05,64.5 60.41,64.86 61.73,64.86 62.79,65.91 67.51,65.91 68.25,66.65 69.14,66.65 69.67,66.12 69.67,65.74 v4(69.47,65.53)
MDSI_A3_DP_C: length 4
  BOTTOM w0.076: CN9.30 56.45,39.22 56.63,39.4 56.63,41.47 56.26,41.83 L14.2
MDSI_A_CLKN: length 46.1
  IN2 w0.07: v4(67.71,66.91) 67.61,66.8 67.61,66.45 67.21,66.05 67.21,65.9 68.3,64.81 68.3,64.52 69.38,63.43 69.38,62.41 69.11,62.14 69.11,60.59 68.23,59.71 68.23,58.05 63.51,53.32 63.51,52.48 61.11,50.07 56.47,50.07 54,47.6 54,45.75 53.74,45.49 53.59,45.49 53.49,45.39 53.49,45.13 53.59,45.03 53.74,45.03 53.95,44.83 53.95,44.42 53.74,44.22 53.49,44.22 53.39,44.12 v4(53.39,43.74)
  IN3 w0.07: v4(67.71,66.91) 67.64,66.98 67.64,67.51 67.19,67.97 65.15,67.97 64.67,67.48 62.32,67.48 61.74,66.91 60.76,66.91 59.63,65.78 59.07,65.78 58.58,65.29 v8(58.45,65.29) ; v1(53.44,44.22) 53.27,44.05 53.27,43.86 v4(53.39,43.74)
MDSI_A_CLKN_C: length 4
  BOTTOM w0.076: L12.3 53.51,41.91 53.21,41.61 53.21,39.14 53.45,38.9 CN9.25
MDSI_A_CLKP: length 46
  IN2 w0.07: v4(52.83,43.74) 52.88,43.74 53.22,44.08 53.22,44.19 53.42,44.39 53.67,44.39 53.77,44.5 53.77,44.76 53.67,44.86 53.52,44.86 53.32,45.06 53.32,45.46 53.52,45.66 53.67,45.66 53.83,45.82 53.83,47.67 56.4,50.24 61.04,50.24 63.34,52.55 63.34,53.4 68.06,58.12 68.06,59.78 68.94,60.66 68.94,62.21 69.21,62.48 69.21,63.36 68.13,64.45 68.13,64.74 67.03,65.83 67.03,66.12 67.43,66.52 67.43,66.69 67.22,66.91 v4(67.13,66.91)
  IN3 w0.07: v4(67.13,66.91) 67.21,66.91 67.47,67.16 67.47,67.44 67.11,67.79 65.22,67.79 64.74,67.31 62.39,67.31 61.82,66.73 60.83,66.73 59.7,65.61 59.14,65.61 59,65.47 59,65.38 v8(59.05,65.33) ; v1(52.78,44.22) 53.04,44.22 53.1,44.17 53.1,44.01 v4(52.83,43.74)
MDSI_A_CLKP_C: length 4
  BOTTOM w0.076: CN9.24 52.85,38.94 53.06,39.14 53.06,41.48 52.71,41.83 L12.2
MDSI_COMP: length 1.7
  IN2 w0.114: v5(57.15,66.19) 56.53,65.58 56.13,65.58 56.11,65.6 v12(56.08,65.6)
  IN3 w0.254: v12(56.08,65.6) 56.11,65.6 56.13,65.58 v8(56.47,65.58)
MDSI_DDC_SCL: length 88.1
  TOP w0.114: v5(60.98,38.2) 60.98,38.05 60.47,37.54 R74.2 60.11,37.53 59.71,37.13 Q3.2
  IN2 w0.064: v4(50.31,78.21) 50.77,77.75 51.36,77.75 51.53,77.93 51.53,79.03 52.46,79.96 56.4,79.96 57.97,78.39 62.25,78.39 62.44,78.2 62.44,77.05 64.2,75.29 64.77,75.29 65.16,74.91 67.26,74.91 67.75,75.39 69.53,75.39 69.95,74.97 69.95,72.98 70.41,72.52 71.17,72.52 71.51,72.18 72.96,72.18 75.49,69.66 75.49,64.29 74.41,63.21 74.41,61.73 74.72,61.41 74.72,55.11 75.03,54.8 75.03,54.1 75.76,53.37 75.76,47.19 75.21,46.64 75.21,45.94 72.99,43.72 72.99,39.71 72.04,38.76 61.36,38.76 60.98,38.38 v5(60.98,38.2)
  IN3 w0.06: 51.06,71.78 51.06,71.56 v8(51.06,71.56)
  IN3 w0.064: 51.06,71.78 51.06,72.42 51.47,72.84 51.47,74.03 51.76,74.32 51.76,75.73 50.68,76.82 50.68,77.39 50.67,77.4 50.67,77.85 v4(50.31,78.21)
MDSI_DDC_SDA: length 85.1
  TOP w0.114: v5(60.47,39.31) 60.45,39.29 Q2.2
  IN2 w0.064: v4(50.31,77.62) 50.39,77.55 51.43,77.55 51.69,77.8 51.69,78.97 52.5,79.78 56.36,79.78 57.91,78.23 62.19,78.23 62.29,78.13 62.29,76.51 62.43,76.37 62.43,76.02 63.31,75.14 64.68,75.14 65.07,74.75 65.63,74.75 67.21,73.18 67.21,72.29 67.67,71.83 69.41,71.83 69.94,72.36 71.12,72.36 71.45,72.03 72.9,72.03 75.33,69.6 75.33,64.37 74.25,63.29 74.25,61.66 74.56,61.35 74.56,55.05 74.88,54.73 74.88,53.44 75.05,53.27 75.05,46 72.84,43.79 72.84,39.77 71.98,38.91 60.87,38.91 v5(60.47,39.31)
  IN3 w0.064: v4(50.31,77.62) 50.31,77.42 50.52,77.21 50.52,76.75 51.61,75.67 51.61,74.39 51.32,74.09 51.32,72.91 50.81,72.41 v8(50.81,71.88)
MICVDD: length 2
  BOTTOM w0.508: R367.2 C322.1 114.66,79.1 C321.2
MICVDD_C: length 2.1
  BOTTOM w0.203: U34.3 116.1,76.73 116,76.84 116,77.26 R367.1
MUX_OUT_SX_S: length 23.8
  IN2 w0.064: v5(72.7,53.87) 72.44,53.62 72.44,52.05 72.9,51.59 72.9,49.03 71.02,47.14 71.02,46.53 v4(71.04,46.51)
  IN3 w0.064: v1(58.39,51.33) 59.06,50.66 61.17,50.66 63.98,47.85 65.69,47.85 66.81,46.73 70.82,46.73 v4(71.04,46.51)
  BOTTOM w0.114: v1(58.39,51.33) 58.39,51.2 58.19,50.99 PR53.2
NGFF_RESET#: length 134.7
  IN2 w0.064: v4(26.11,13.54) 26.44,13.54 26.54,13.64 26.54,20.47 28.65,22.58 28.65,25.38 35,31.73 37.95,31.73 40.65,34.43 40.65,35.44 43.15,37.95 56.18,37.95 56.66,37.47 66.16,37.47 66.7,38 72.14,38 73.6,39.46 73.6,43.47 75.82,45.69 75.82,46.38 76.37,46.94 76.37,54.48 75.79,55.07 75.79,55.11 75.48,55.42 75.48,60.74 76.25,61.51 76.25,70.73 74.19,72.8 74.19,75.29 73.38,76.1 69.97,76.1 69.91,76.15 66.27,76.15 v4(66.14,76.02)
  IN3 w0.06: 54.35,71.78 54.35,71.45 54.14,71.25 54.14,70.63 54.3,70.47 54.41,70.47 v8(54.49,70.39)
  IN3 w0.064: v4(66.14,76.02) 65.83,75.72 65.3,75.72 64.95,76.07 64.95,76.63 65.05,76.73 65.05,77.69 64.59,78.16 58.54,78.16 57.7,77.31 56.95,77.31 56.66,77.03 56.66,76.13 55.67,75.13 55.67,74.93 55.32,74.58 55.32,74.04 54.87,73.59 54.87,72.81 54.38,72.32 54.38,71.81 54.35,71.78 ; v1(24.66,13.49) 24.71,13.54 v4(26.11,13.54)
  BOTTOM w0.114: R236.1 24.79,13.36 v1(24.66,13.49) 24.79,13.62 R235.2
NGFF_RESET#_C: length 7.3
  BOTTOM w0.114: CN7.67 21.05,9.02 21.23,9.2 23.96,9.2 C163.1 24.33,10.48 24.33,11.51 24.79,11.96 R236.2
P1_SENSOR_INT: length 132.8
  TOP w0.114: U12.A7 114.46,57.2 v5(114.02,57.2)
  IN2 w0.064: v4(96.75,44.63) 96.72,44.65 96.72,45.43 97,45.71 97,48.16 98.83,49.99 98.83,58.52 100.91,60.61 102.02,60.61 102.23,60.82 103.59,60.82 104.44,59.97 104.78,59.97 105.89,58.86 107.71,58.86 108.81,57.76 109.72,57.76 110.26,57.23 113.26,57.23 113.46,57.43 113.79,57.43 v5(114.02,57.2)
  IN3 w0.064: v4(96.75,44.63) 96.72,44.6 v11(96.72,44.17) ; v1(25.04,33.68) 25.24,33.89 34.52,33.89 35.98,32.42 39.82,32.42 41.3,33.9 41.3,34.7 41.45,34.85 44.32,34.85 45.06,34.11 57.45,34.11 57.89,33.68 96.46,33.68 v11(96.57,33.78)
  IN4 w0.127: v11(96.57,33.78) 96.72,33.94 v11(96.72,44.17)
  BOTTOM w0.114: U19.1 15.18,33.69 15.14,33.64 R217.2 15.83,33.09 15.97,32.95 15.97,31.7 16.33,31.35 20.52,31.35 22.86,33.68 v1(25.04,33.68)
P2_SENSOR_INT: length 152.8
  TOP w0.114: v5(113.59,57.18) 113.94,57.53 114.27,57.53 114.58,57.84 U12.A8
  IN2 w0.064: v5(113.59,57.18) 113.43,57.02 109.32,57.02 107.64,58.7 105.79,58.7 104.67,59.82 104.37,59.82 103.53,60.66 102.28,60.66 102.08,60.45 100.99,60.45 98.98,58.45 98.98,49.76 97.18,47.96 v4(97.18,44.98)
  IN3 w0.064: v11(97.2,44.53) 97.18,44.55 v4(97.18,44.98) ; v11(97,33.78) 96.74,33.53 57.66,33.53 57.35,33.83 45.08,33.83 44.83,33.58 44.83,32.84 44.5,32.51 43,32.51 42.31,33.2 41.93,33.2 40.24,31.51 35.64,31.51 34.15,33 27.99,33 24.69,29.69 24.69,27.36 24.84,27.2 24.84,15.72 28.34,12.22 28.34,11.84 28.11,11.61 19.1,11.61 v1(17.42,9.93)
  IN4 w0.127: v11(97,33.78) 97.18,33.96 97.18,44.5 v11(97.2,44.53)
  BOTTOM w0.114: R219.2 17.21,10.11 U20.1
P_3_S_EN: length 3
  BOTTOM w0.114: PR59.1 66.06,72.62 66.26,72.42 ; 66.26,72.42 66.39,72.54 66.7,72.54 66.91,72.33 PU3.4 ; 66.26,72.42 PU3.3
P_RCOMP_N: length 4.8
  IN4 w0.07: v8(58.73,58.22) 59.77,58.22 62.01,55.98 62.33,55.98 v1(62.51,56.16)
P_RCOMP_P: length 4.8
  IN4 w0.07: v1(62.51,55.4) 62.51,55.68 62.4,55.78 61.92,55.78 59.68,58.02 59.1,58.02 v8(59.02,57.94)
PANEL_EN: length 64.8
  TOP w0.114: 48.62,39.1 48.62,39.94 Q23.1 ; 48.62,39.1 R669.2 ; 48.62,39.1 49.04,39.52 49.81,39.52 50.42,38.91 50.42,36.25 51.33,35.33 59.46,35.33 60.22,36.09 61.13,36.09 v5(61.62,36.58)
  IN2 w0.064: v4(79.27,64.02) 78.38,63.13 78.38,62.76 77.87,62.26 77.87,61.24 78.07,61.04 78.07,50.12 78.25,49.94 78.25,46.62 74.67,43.03 74.67,38.98 72.07,36.39 61.8,36.39 v5(61.62,36.58)
  IN3 w0.06: 81.51,63.04 81.53,63.06 82.47,63.06 82.87,62.67 83.32,62.67 83.68,63.02 v8(83.68,63.15)
  IN3 w0.064: 81.51,63.04 81.3,63.04 80.33,64.02 v4(79.27,64.02)
PLT_CLK0_CAM1: length 53.4
  IN2 w0.064: v4(18.82,56.29) 20.6,56.29 21.71,55.17 21.71,49.1 23.49,47.32 40.41,47.32 48.21,55.12 54.03,55.12 54.69,55.78 57.1,55.78 v12(57.25,55.93)
  IN3 w0.064: v12(57.25,55.93) 57.26,55.93 57.59,55.6 58.03,55.6 v11(58.04,55.6) ; v4(18.82,56.29) 18.69,56.29 v1(18.31,55.91)
  IN4 w0.06: v11(58.04,55.6) 57.4,56.24 57.4,56.53 57.56,56.69 57.56,56.85 57.4,57.01 57.4,57.17 57.6,57.37 v8(57.6,57.65)
PLT_CLK1_CAM2: length 53.1
  IN2 w0.064: v4(20.72,48.54) 22.12,47.14 23.4,47.14 23.41,47.13 40.49,47.13 48.27,54.92 54.1,54.92 54.77,55.59 57.41,55.59 v12(57.76,55.93)
  IN3 w0.064: v1(14.42,43.46) 17.8,43.46 19.3,44.96 19.3,47.12 v4(20.72,48.54) ; v11(58.16,55.93) v12(57.76,55.93)
  IN4 w0.06: v11(58.16,55.93) 58.16,56.17 57.68,56.65 57.68,56.89 57.89,57.09 v8(57.89,57.37)
PLT_CLK3_I2SMCLK: length 75.7
  IN3 w0.064: v11(60.6,54.13) 60.65,54.08 62.88,54.08 63.87,53.08 63.87,51.96 64.7,51.13 64.92,51.13 66.61,49.44 67.46,49.44 67.66,49.23 69.09,49.23 69.4,48.92 71.4,48.92 73.84,46.48 79.81,46.48 80.44,45.84 81.71,45.84 82.06,45.49 89.44,45.49 89.65,45.7 91.47,45.7 91.64,45.87 96.2,45.87 96.78,46.46 99.09,46.46 102.2,49.56 103.3,49.56 107.13,53.39 107.13,57.65 110.64,61.15 110.64,64.37 v1(110.69,64.42)
  IN4 w0.06: v8(58.17,57.09) 58.17,56.81 58.49,56.48 58.49,56.41 58.67,56.23 58.67,55.09 58.95,54.81
  IN4 w0.064: v11(60.6,54.13) 60.22,54.51 59.25,54.51 58.95,54.81
  BOTTOM w0.114: v1(110.69,64.42) 109.88,64.42 109.62,64.67 109.62,67.21 110.13,67.72 R351.1
PLTRST#: length 172.6
  TOP w0.114: CN1.23 v5(61.82,73.14) 61.82,72.04 61.64,71.86 v5(61.64,71.48) ; v5(71.19,65.48) 72.44,64.24 75.08,64.24 75.36,64.52 75.36,65.94 75.74,66.32 76.63,66.32 v13(76.86,66.09) 78.28,66.09 78.51,66.32 79.35,66.32 v5(79.54,66.13)
  IN2 w0.064: v5(61.64,71.48) 61.89,71.48 62.52,70.84 63.17,70.84 65.86,68.14 68.36,68.14 68.82,67.68 68.82,66.98 69.16,66.64 70.11,66.64 71.21,65.55 71.21,65.5 v5(71.19,65.48) 71.49,65.18 71.49,61.56 71.22,61.28 71.22,59.78 70.37,58.93 70.37,54.95 71.22,54.1 71.22,51.46 71.68,51 71.68,50.46 71.44,50.22 71.15,50.22 70.8,50.57 68.04,50.57 65.23,47.77 63.51,47.77 60.08,44.34 60.08,42.82 56.77,39.5 v4(56.77,38) ; v5(61.82,73.14) 61.82,73.15 58.85,73.15 58.64,73.36 57.88,73.36 57.48,72.97 56.33,72.97 56.21,73.1 54.69,73.1 v12(54.53,72.93) ; v5(79.54,66.13) 80.29,66.88 v12(80.29,68.07) 81.15,68.07 84.45,71.38 85.58,71.38 85.93,71.73 91.59,71.73 91.69,71.83 94.06,71.83 97.01,68.88 97.01,68.31 99.34,65.99 104.82,65.99 105.57,65.24 109.62,65.24 109.81,65.43 111.88,65.43 112.85,64.46 112.85,64.15 113.14,63.86 v5(114.32,63.86)
  IN3 w0.06: 81.51,64.75 81.63,64.62 81.96,64.62 82.19,64.39 82.72,64.39 83.17,63.95 v8(83.28,63.95) ; v8(54.21,70.1) 54.02,70.29 54.02,71.35 54.16,71.48 54.16,71.78
  IN3 w0.064: v1(20.5,23.43) 21.1,23.43 21.9,24.24 21.9,29.97 23.05,31.11 23.05,33.4 24.59,34.94 34.93,34.94 36.41,33.47 39.39,33.47 40.26,34.33 40.26,35.13 41.02,35.89 44.75,35.89 45.49,35.16 55.41,35.16 56.71,36.46 56.71,37.95 v4(56.77,38) ; v12(80.29,68.07) 80.26,68.05 80.26,65.56 81.07,64.75 81.51,64.75 ; 54.16,71.78 54.16,71.86 54.19,71.89 54.19,72.59 v12(54.53,72.93)
PMIC_AGND: length 14.7
  IN3 w0.254: v10(86.33,59.74) 86.48,59.74 86.74,60 v12(86.74,60.76) 86.74,60.89 v11(86.48,61.15) ; v12(86.08,65.56) v8(86.08,65.15)
  GND3 w0.203: 81.15,60.56 81.61,60.56 81.76,60.71 81.76,60.86 81.96,61.06 82.47,61.06 82.6,61.19 82.83,61.19 v8(82.88,61.15) ; v8(86.08,65.15) v8(85.28,65.15)
  GND3 w0.254: v8(82.88,61.15) 82.83,61.09 82.83,60.53 82.85,60.5 82.85,60.02 83.13,59.74 v10(86.33,59.74) ; v8(84.48,65.15) 84.48,65.33 84.66,65.51 85.02,65.51 85.28,65.25 v8(85.28,65.15) ; v8(82.48,62.35) 81.92,62.35 81.78,62.21 81.3,62.21 80.97,61.88 80.97,61.34 80.87,61.24 80.87,60.83 80.99,60.71 81,60.71 81.15,60.56
  IN4 w0.254: v11(86.48,61.15) v8(86.48,61.55)
  vias: v2(87.25,60.86) v2(87.47,60.61) v3(87.25,60.86) v3(87.47,60.61) v5(87.25,60.86) v5(87.47,60.61)
PMIC_FABID_0: length 28.8
  TOP w0.114: R124.2 R137.1
  IN2 w0.064: v4(94.41,68.15) 94.08,68.48 v5(94.05,68.48)
  IN3 w0.06: 85.19,60.17 84.85,60.51 84.85,61.69 84.68,61.86 84.68,62.44 84.48,62.64 v8(84.48,62.75)
  IN3 w0.064: v4(94.41,68.15) 94.41,66.98 94.03,66.6 94.03,66.17 94.51,65.69 94.51,64.11 95.02,63.6 95.02,60.01 93.2,58.18 90.92,58.18 88.59,55.86 86.01,55.86 85.62,56.24 85.62,56.43 85.19,56.86 85.19,58.27 85.54,58.62 85.54,59.82 85.19,60.17
PMIC_FABID_1: length 15.9
  TOP w0.114: v5(94,60.66) 94,62.33 94.99,63.32 94.99,63.73 94,64.72 94,64.87 93.96,64.91 R141.1 R128.2
  IN2 w0.064: v5(94,60.66) 94,60.22 v4(94.01,60.21)
  IN3 w0.06: v8(85.68,61.95) 86.21,61.95 86.99,61.16 87.45,61.16
  IN3 w0.064: v4(94.01,60.21) 93.77,59.97 88.72,59.97 87.53,61.16 87.45,61.16
PMIC_INT: length 38.5
  IN3 w0.064: v11(55.11,72.82) 55.11,73.61 55.51,74 55.51,74.51 55.85,74.86 55.85,75.06 56.84,76.05 56.84,76.99 57.01,77.16 57.76,77.16 58.61,78 64.51,78 64.9,77.62 64.9,76.79 64.8,76.69 64.8,75.85 65.08,75.57 66.2,75.57 67.63,76.99 76.53,76.99 77.27,76.25 78.64,76.25 79.04,75.85 79.49,75.85 v11(79.52,75.82)
  IN4 w0.06: v11(55.11,72.82) 55.11,72.3 54.89,72.08 54.89,71.47 54.97,71.39 54.97,71.04 v8(55.06,70.95)
  IN4 w0.127: v1(84.22,77.08) 84.22,77.07 82.98,75.82 v11(79.52,75.82)
PMIC_INT_R: length 22.1
  IN3 w0.06: v8(83.68,63.55) 83.48,63.75 82.25,63.75 81.82,64.17 81.51,64.17
  IN3 w0.064: v1(83.72,77.52) 83.27,77.08 83.27,72.13 82.89,71.75 80.29,71.75 78.36,69.81 78.36,68.02 78.58,67.79 79.04,67.79 79.3,67.54 79.3,65.92 81.05,64.17 81.51,64.17
  BOTTOM w0.114: PR93.1 83.98,77.92 83.72,77.65 v1(83.72,77.52)
PMIC_MEMCFG0: length 14.1
  TOP w0.114: R138.1 v5(93.95,67.59) R125.2
  IN2 w0.064: v4(93.75,67.21) 93.95,67.41 v5(93.95,67.59)
  IN3 w0.06: 87.45,63.45 86.66,63.45 85.96,62.75 v8(84.88,62.75)
  IN3 w0.064: v4(93.75,67.21) 93.47,66.93 93.47,63.81 93.32,63.65 88.95,63.65 88.74,63.45 87.45,63.45
PMIC_MEMCFG1: length 17.1
  TOP w0.114: R127.2 R140.1
  IN2 w0.064: v4(94.08,65.28) 93.9,65.46 v5(93.9,65.71)
  IN3 w0.06: 87.45,60.48 87.45,60.53 86.2,61.77 85.85,61.77 85.8,61.72 85.57,61.72 85.35,61.95 v8(85.28,61.95)
  IN3 w0.064: v4(94.08,65.28) 94.08,62.33 94.41,62 94.41,60.05 94.15,59.79 88.64,59.79 88.11,60.33 87.6,60.33 87.45,60.48
PMIC_VBUS_DIV: length 23.8
  TOP w0.114: v5(96.01,62.61) 96.01,62.46 96.34,62.13 v13(96.34,62.13) 96.34,62.13 96.42,62.05 PR146.1 PR147.2
  IN2 w0.064: v5(96.01,62.61) 95.86,62.46 94.66,62.46 v4(94.46,62.66)
  IN3 w0.06: 85.44,60.17 84.97,60.65 84.97,61.76 84.88,61.86 v8(84.88,61.95)
  IN3 w0.064: 85.44,60.17 85.7,59.92 85.7,58.52 85.37,58.19 85.37,56.9 85.8,56.47 85.8,56.28 86.02,56.06 88.44,56.06 91.8,59.42 94.22,59.42 94.81,60.02 94.81,62.31 v4(94.46,62.66)
PMIC_VDCIN_ACOK: length 26.8
  TOP w0.114: PR145.1 PR148.2 v13(98.19,62.26) 97.74,62.71 v5(96.87,62.71)
  IN2 w0.064: v4(95.58,62.84) 95.7,62.97 96.62,62.97 v5(96.87,62.71)
  IN3 w0.06: 84.77,60.17 84.77,60.36 84.73,60.4 84.73,61.57 84.48,61.83 v8(84.48,61.95)
  IN3 w0.064: v4(95.58,62.84) 95.58,60.22 93.36,58 91.35,58 88.34,54.99 85.7,54.99 85.49,55.2 85.49,56.14 85.04,56.59 85.04,58.55 84.77,58.82 84.77,60.17
PMU_BATTLOW#: length 37.5
  IN3 w0.064: v11(80.54,76.13) 79.93,76.13 79.34,76.71 77.46,76.71 76.13,78.04 65.78,78.04 64.9,78.92 57.48,78.92 56.79,78.23 55.01,78.23 54.63,77.85 54.63,77.32 54.5,77.19 54.5,76.89 53.99,76.38 53.99,74.71 v11(54.12,74.58)
  IN4 w0.06: v11(54.12,74.58) 54.1,74.58 53.91,74.38 53.91,72.37 53.16,71.62 53.16,71.44 53.36,71.24 v8(53.36,70.95)
  IN4 w0.127: v11(80.54,76.13) 80.54,76.3 80.64,76.4 81.78,76.4 v1(82.34,76.96)
PMU_BATTLOW#_R: length 23.4
  IN3 w0.064: v1(82.55,78.03) 82.94,77.64 82.94,72.35 82.64,72.05 80.17,72.05 78,69.89 78,66.45 77.37,65.81 77.37,65.2 77.44,65.13 77.84,65.13 78,65.13 78.32,65.45 79.34,65.45 81.43,63.36 81.57,63.36 81.58,63.35 82.6,63.35 82.8,63.15 v8(82.88,63.15)
PMU_RESET_OUT_1V8#: length 20.2
  IN2 w0.064: v5(117.1,58.34) 117.19,58.25 117.19,57.13 117.5,56.82 117.5,53.11 118.28,52.33 118.28,50.88 119.86,49.3 119.86,45.37 117.65,43.16 114.75,43.16 v5(114.7,43.21)
POWER_BUTTON_I_EC: length 152.9
  TOP w0.114: R197.1 v9(4.26,68.23)
  IN2 w0.064: v5(115.1,58.34) 115.1,58.15 115.29,57.96 115.29,55.35 115.16,55.22 114.6,55.22 113.53,56.29 111.27,56.29 110.69,56.87 109.24,56.87 107.59,58.52 105.71,58.52 105.32,58.92 105.06,58.92 v4(104.62,59.36)
  IN3 w0.064: v4(104.62,59.36) 104.62,59.74 107.85,62.97 107.85,66.3 108.98,67.44 108.98,69.12 103.65,74.45 98.32,74.45 97.28,75.49 87.87,75.49 86.43,76.93 86.43,77.35 86.16,77.62 86.16,79.23 83.65,81.74 81.11,81.74 80.99,81.61 70.11,81.61 69.52,82.21 69.52,82.6 68,84.11 62.85,84.11 61.11,85.85 58.77,85.85 56.97,84.05 53.13,84.05 51.91,82.83 24.1,82.83 22.35,81.08 11.35,81.08 9.83,79.55 9.83,76.23 7.13,73.53 5.13,73.53 4.29,72.7 4.29,68.25 v9(4.26,68.23)
POWER_BUTTON_I_EC_C: length 7.7
  TOP w0.114: SW1.5 4.78,61.81 5.36,62.38 5.36,63.78 5.57,64 T1.2 5.57,65.44 5.9,65.78 R199.2 R198.1 R197.2
POWER_BUTTON_INPUT: length 167.1
  TOP w0.114: v5(67.33,82.45) 67.33,79.27 67.21,79.15 66.77,79.15 66.25,78.63 66.25,78.18 R88.2 ; R169.2 111.69,64.84 111.4,64.54 111.4,63.4 v5(111.66,63.15) ; R198.2 v9(4.26,67.34)
  IN2 w0.064: v4(99.44,65.61) 104.9,65.61 105.46,65.05 108.07,65.05 109.62,63.5 110.03,63.5 110.39,63.15 v5(111.66,63.15) ; v4(93.54,60.66) 93.98,61.09 v4(97.96,61.09) ; v5(67.33,82.45) v4(69.06,82.45)
  IN3 w0.06: v8(84.48,63.55) 84.51,63.55 84.68,63.38 84.68,62.66 84.68,62.66 84.68,62.64 85.09,62.23 85.75,62.23 85.87,62.1 86.23,62.1 87.02,61.32 87.45,61.32
  IN3 w0.064: v4(97.96,61.09) 98.27,61.39 98.27,65.33 98.55,65.61 v4(99.44,65.61) 99.44,67.21 98.9,67.74 98.9,73.48 97.13,75.26 87.88,75.26 86.41,76.73 86.1,76.73 85.87,76.96 85.87,77.16 86.01,77.29 86.01,79.17 83.59,81.59 81.18,81.59 81.05,81.46 70.05,81.46 v4(69.06,82.45) 67.55,83.96 62.7,83.96 60.96,85.7 58.87,85.7 57.02,83.85 53.36,83.85 52.19,82.68 24.27,82.68 22.44,80.85 11.38,80.85 10.08,79.55 10.08,76.18 7.21,73.31 5.28,73.31 4.87,72.9 4.87,67.95 v9(4.26,67.34) ; 87.45,61.32 87.75,61.32 88.92,60.15 93.04,60.15 v4(93.54,60.66)
POWER_BUTTON_O_EC: length 4.2
  TOP w0.114: U12.G9 113.45,60.84 112.72,61.57 112.72,63.69 R169.1
PROCHOT#: length 69.6
  IN3 w0.064: v1(52.12,73.94) 51.95,74.11 51.95,75.81 51.17,76.59 51.17,77.93 51.25,78 51.25,79.7 54.84,83.29 57.16,83.29 59.08,85.21 60.75,85.21 62.49,83.47 67.06,83.47 69.57,80.96 83.24,80.96 85.51,78.7 85.51,77.51 85.34,77.34 85.34,76.23 86.65,74.92 86.65,72.21 85.77,71.33 84.58,71.33 81.92,68.67 81.68,68.67 80.82,67.81 80.82,67.74 80.64,67.57 80.64,66.24 81.61,65.28 81.94,65.28 82.09,65.43 82.34,65.43 82.98,64.8 82.98,64.64 v8(83.68,63.95)
  IN4 w0.06: v8(51.09,70.95) 51.01,71.04 51.01,71.32 50.86,71.47 50.86,71.64 51.03,71.81 51.03,72.25 51.33,72.54 51.33,73.15 v1(52.12,73.94)
PROG_SPI_CLK: length 17.6
  TOP w0.114: CN1.41 60.62,76.05 v5(60.63,76.05)
  IN2 w0.064: v5(60.63,76.05) 60.88,75.8 61.11,75.8 61.26,75.95 62.04,75.95 63.15,74.84 64.41,74.84 64.79,74.45 65.35,74.45 66.81,73 66.81,72.15 67.45,71.51 70.48,71.51 70.83,71.16 70.98,71.16 71.29,70.84 72.07,70.84 73.13,69.78 73.76,69.78 74.18,69.35 v5(74.18,69.23)
PROG_SPI_CS#: length 19.4
  TOP w0.114: v5(60.22,76.05) 60.22,76.02 60.22,76.02 CN1.42
  IN2 w0.064: v5(60.22,76.05) 60.22,76.02 60.6,75.64 61.17,75.64 61.25,75.72 61.33,75.8 61.98,75.8 63.09,74.68 64.34,74.68 64.73,74.3 65.28,74.3 66.65,72.92 66.65,71.97 67.27,71.36 70.41,71.36 70.76,71.01 70.88,71.01 71.19,70.69 71.98,70.69 73.14,69.53 73.76,69.53 73.93,69.36 73.93,69.12 73.94,69.12 73.8,68.98 73.57,68.98 73.32,68.73 v5(72.68,68.73)
PROG_SPI_IO3: length 62.1
  TOP w0.114: v5(61.01,76.05) 61.02,76.03 CN1.40 ; U5.B1 66.32,43.88 R90.2 66.28,41.95 v5(66.16,41.84)
  IN2 w0.064: v5(61.01,76.05) 61.06,76.1 62.11,76.1 63.22,74.99 64.51,74.99 64.89,74.6 65.43,74.6 66.96,73.07 66.96,72.28 67.57,71.67 70.53,71.67 70.89,71.31 71.05,71.31 71.37,70.99 72.41,70.99 73.35,70.05 73.76,70.05 74.44,69.37 74.44,69.1 74.1,68.76 73.72,68.76 v5(73.68,68.73) 73.18,68.23 v5(73.18,67.73) 73.33,67.73 73.43,67.83 73.43,67.83 73.58,67.97 73.78,67.97 74.43,67.33 74.43,66.84 73.49,65.9 73.49,60.67 73.2,60.38 73.2,55.33 74.09,54.44 74.09,52.73 74.27,52.55 74.27,46.29 72.08,44.1 72.08,40.1 71.78,39.8 66.42,39.8 66.16,40.06 v5(66.16,41.84)
PROG_SPI_MISO: length 17.5
  TOP w0.114: v5(59.84,76.05) 59.82,76.03 CN1.43
  IN2 w0.064: v5(73.18,69.23) 72.83,69.23 71.52,70.54 71.09,70.54 70.8,70.83 70.72,70.83 70.39,71.17 67.14,71.17 66.5,71.8 66.5,72.85 65.2,74.14 64.64,74.14 64.25,74.53 63.03,74.53 61.92,75.64 61.39,75.64 61.24,75.49 60.4,75.49 v5(59.84,76.05)
PROG_SPI_MOSI: length 18.5
  TOP w0.114: CN1.44 59.42,76.01 v5(59.46,76.05)
  IN2 w0.064: v5(59.46,76.05) 60.93,74.58 62.65,74.58 62.85,74.38 64.19,74.38 64.58,73.99 65.13,73.99 66.35,72.77 66.35,71.65 66.98,71.01 70.32,71.01 70.66,70.68 70.7,70.68 70.99,70.38 71.42,70.38 72.87,68.94 73.24,68.94 73.44,69.13 73.59,69.13 v5(73.68,69.23)
PWR_3P3_SX_EN: length 36.3
  IN3 w0.064: v11(52.6,73.18) 52.6,73.36 53.08,73.83 53.08,75.6 51.83,76.85 51.83,77.52 51.91,77.6 51.91,79.4 53.87,81.36 67.15,81.36 v11(67.84,80.67)
  IN4 w0.06: v11(52.6,73.18) 52.22,73.18 51.15,72.11 51.15,71.74 51.28,71.62 51.28,71.48 51.18,71.38 51.18,71.32 51.18,71.15 52.23,70.1 v8(52.23,69.82)
  IN4 w0.127: v11(67.84,80.67) 66.37,79.2 66.37,74.16 v1(66.06,73.85)
PWR_SD_EN: length 5.6
  TOP w0.114: C125.2 125.45,65.6 125.45,67.39 PQ2.2 ; C125.2 124.99,64.67 124.84,64.52 124.84,64.21 125.1,63.95 Q11.6 ; C125.2 R181.2
REAR_CAM_LED: length 15.3
  IN3 w0.06: v8(49.11,69.54) 49.11,69.75 49.17,69.8 49.17,70.99 49.44,71.26 49.44,71.78
  IN3 w0.064: 49.44,71.78 49.44,73.57 49.3,73.71 49.3,75.03 49.12,75.21 47.77,75.21 46.73,76.25 46.73,78.54 46.12,79.15 v1(46.12,80.54)
  BOTTOM w0.114: v1(46.12,80.54) 45.46,80.54 44.73,79.81 TP46.1
RES_GYRO: length 2.2
  BOTTOM w0.114: U32.14 96.18,37.93 C302.1
RF_KILL: length 3.5
  TOP w0.114: Q1.2 R18.2 38.58,12.61 Q1.3
RF_KILL#: length 136.9
  TOP w0.114: Q1.5 34.9,11.96 34.64,12.22 27.96,12.22 v9(27.84,12.09)
  IN2 w0.064: v12(54.95,72.43) 55.14,72.25 55.59,72.25 55.8,72.04 55.8,71.68 55.62,71.5 55.62,71.17 56.31,70.49 56.31,70 56.13,69.83 55.32,69.83 54.51,70.64 53.16,70.64 52.85,70.33 52.13,70.33 50.23,72.24 47.56,72.24 44.42,75.38 44.42,79.94 42.39,81.97 26.13,81.97 24.79,80.62 24.79,49.81 24.28,49.3 v4(24.23,49.3)
  IN3 w0.06: 54.53,71.78 54.53,71.38 54.26,71.1 54.26,70.68 54.35,70.59 54.61,70.59 54.69,70.51 54.69,70.16 54.49,69.96 v8(54.49,69.82)
  IN3 w0.064: v12(54.95,72.43) 54.53,72.02 54.53,71.78 ; v4(24.23,49.3) 23.09,49.3 21.21,47.42 21.21,42.55 23.12,40.63 23.12,34.33 21.38,32.59 21.38,31 18.17,27.79 18.17,15.46 18.97,14.66 18.97,13.08 19.96,12.09 v9(27.84,12.09)
RF_KILL#_R: length 9.8
  TOP w0.114: v9(33.55,8.94) 33.55,10.09 34.78,11.31 Q1.6
  BOTTOM w0.114: R278.2 33.68,9.07 v9(33.55,8.94) 33.6,8.89 33.6,7.44 34.23,6.81 35.53,6.81 35.8,6.54 CN7.8
ROTATION_R: length 9.7
  IN3 w0.06: v8(56.47,58.22) 56.41,58.16 56.41,57.78 57,57.2 60.25,57.2 60.75,56.69 60.98,56.69
  IN3 w0.064: v1(63.14,56.39) 62.55,56.39 62.25,56.69 60.98,56.69
  BOTTOM w0.114: v1(63.14,56.39) 63.14,56.67 62.46,57.35 TP58.1
RSMRST#: length 44.3
  TOP w0.114: v13(65.58,78.49) 65.17,78.08 v5(65.17,77.88)
  IN2 w0.064: v5(65.17,77.88) 65.1,77.95 64.51,77.95 64.18,77.62 v4(64.13,77.62)
  IN3 w0.064: v4(64.13,77.62) 63.85,77.34 v1(63.85,77.09) 63.84,77.08 63.84,77.07 62.71,75.94 62.71,75.45 62.71,75.45 62.71,75.39 62.53,75.21 62.27,75.21 62.18,75.31 61.13,75.31 59.94,74.12 59.41,74.12 v11(58.44,73.15)
  IN4 w0.06: v11(58.44,73.15) 58.42,73.18 58.01,73.18 57.36,72.52 v8(57.36,71.56) ; 81.35,63.1 81.9,62.55 82.96,62.55 83.08,62.66 83.08,63.35 v8(82.88,63.55)
  IN4 w0.064: v1(68.48,63.27) 68.63,63.12 75.59,63.12 75.69,63.22 78.13,63.22 78.15,63.2 81.25,63.2 81.35,63.1 ; v1(67.97,66.07) 67.8,66.24 67.8,70.84 64.82,73.81 64.49,73.81 63.98,74.32 63.98,76.96 v1(63.85,77.09)
  BOTTOM w0.114: v1(68.48,63.27) 68.48,65.56 v1(67.97,66.07)
RTC_XTAL_IN: length 7.4
  IN4 w0.064: v8(57.6,71.88) 57.78,71.88 60.22,74.32 60.22,75.55 v1(60.05,75.72)
  BOTTOM w0.114: v1(60.05,75.72) C275.2 59.32,76.11 59.22,76.21 Y3.1
RTC_XTAL_OUT: length 7.8
  IN4 w0.064: v8(57.89,71.52) 58.05,71.52 60.68,74.14 60.68,75.5 v1(60.89,75.72)
  BOTTOM w0.114: Y3.2 61.72,76.33 61.63,76.24 C288.2 v1(60.89,75.72)
S_D_RS: length 30.4
  IN3 w0.06: 82.71,62.35 81.68,61.32 81.51,61.32
  IN3 w0.064: 81.51,61.32 80.64,61.32 80.44,61.52 79.33,61.52 78.92,61.93 78.92,63.24 77.68,64.48 76.93,64.48 76.29,65.12 76.29,69.54 76.53,69.78 77.2,69.78 79.97,72.55 82.34,72.55 82.45,72.66 82.45,77.14 81.38,78.21 80.26,78.21 80.13,78.08 79.37,78.08 v1(79.07,78.39) ; 82.71,62.35 v8(82.88,62.35)
  BOTTOM w0.114: v1(79.07,78.39) 78.67,77.99 PR80.1
S_RCOMP_N: length 5.8
  IN4 w0.07: v8(58.73,57.09) 59.06,57.09 59.28,57.3 59.45,57.3 61.29,55.46 61.29,53.47 61.19,53.37 v1(60.98,53.37)
S_RCOMP_P: length 5.7
  IN4 w0.07: v8(59.02,57.37) 59.15,57.51 59.53,57.51 61.49,55.55 61.49,53.44 61.57,53.37 v1(61.74,53.37)
SDIO2_CLK: length 123.5
  IN3 w0.064: v11(56.54,51.97) 56.64,51.97 62.63,45.98 64.82,45.98 66.09,44.71 69.56,44.71 70.47,43.8 80.62,43.8 81.54,42.88 96.66,42.88 98.24,44.46 100.94,44.46 110.36,53.88 110.73,53.88 115.83,58.98 117.42,58.98 119.54,61.1 123.19,61.1 126.6,64.51 126.6,66.8 128.54,68.73 131.54,68.73 132.6,69.79 142.6,69.79 150.75,77.93 v1(151.41,77.93) 152.12,77.22 v1(153.96,77.22)
  IN4 w0.06: 53.48,55.89 53.48,56.68 v8(53.36,56.81) ; 55.14,53.48 55.14,53.52 54.71,53.95
  IN4 w0.064: 53.48,55.89 53.6,55.77 53.6,55.06 54.71,53.95 ; v11(56.54,51.97) 56.41,52.1 56.41,52.21 55.14,53.48
SDIO2_CMD: length 126.1
  IN3 w0.064: v11(56.03,52.22) 56.03,51.88 62.29,45.62 64.67,45.62 65.94,44.35 69.29,44.35 70.19,43.44 80.47,43.44 81.39,42.52 96.8,42.52 98.39,44.11 101.09,44.11 110.5,53.53 110.88,53.53 115.98,58.62 117.57,58.62 119.63,60.68 123.33,60.68 126.96,64.31 126.96,66.65 128.69,68.38 131.75,68.38 132.8,69.43 143.87,69.43 151.2,76.77 154.77,76.77 155.22,77.22 v1(155.76,77.22)
  IN4 w0.06: 53.31,55.87 53.31,56.49 53.16,56.65 53.16,56.89 53.36,57.09 v8(53.36,57.37) ; 55.47,52.88 54.87,53.48 54.87,53.58 54.63,53.82
  IN4 w0.064: v11(56.03,52.22) 55.78,52.48 55.78,52.58 55.47,52.88 ; 53.31,55.87 53.45,55.73 53.45,55 54.63,53.82
SDIO2_DATA0: length 124.3
  IN3 w0.064: v1(154.86,78.12) 154.61,77.87 153.86,77.87 153.55,78.18 150.7,78.18 142.49,69.97 132.44,69.97 131.39,68.91 128.47,68.91 126.43,66.87 126.43,64.58 123.12,61.28 119.47,61.28 117.35,59.16 115.75,59.16 110.66,54.06 110.28,54.06 100.86,44.64 98.17,44.64 96.58,43.05 81.61,43.05 80.69,43.98 70.54,43.98 69.63,44.88 66.28,44.88 65.01,46.15 62.72,46.15 56.26,52.61 56.26,52.81 55.37,53.7 55.37,53.8 v11(55.09,54.08)
  IN4 w0.06: 54.8,54.76 54.8,54.78 53.6,55.97 53.6,57.05 v8(53.64,57.09)
  IN4 w0.064: v11(55.09,54.08) 54.86,54.31 54.86,54.7 54.8,54.76
SDIO2_DATA1: length 124.4
  IN3 w0.06: v8(53.07,58.22) 53.11,58.18 53.11,57.18 55.34,54.95 55.34,54.69 55.45,54.59
  IN3 w0.064: 55.45,54.59 55.5,54.54 55.5,53.88 56.44,52.94 56.44,52.69 62.79,46.33 65.08,46.33 66.35,45.06 69.71,45.06 70.62,44.15 80.76,44.15 81.68,43.23 96.51,43.23 98.1,44.82 100.77,44.82 110.18,54.24 110.58,54.24 115.68,59.34 117.22,59.34 119.36,61.48 123.07,61.48 126.25,64.66 126.25,66.94 128.39,69.09 131.25,69.09 132.3,70.14 142.41,70.14 150.63,78.36 153.72,78.36 v1(153.96,78.12)
SDIO2_DATA2: length 125.2
  IN3 w0.06: v11(55.09,54.46) 55.09,54.39 54.87,54.17 54.87,53.94 55.09,53.72
  IN3 w0.064: 55.09,53.72 56.08,52.73 56.08,52.54 56.29,52.33 56.29,51.87 62.36,45.8 64.75,45.8 66.02,44.53 69.49,44.53 70.39,43.62 80.54,43.62 81.46,42.7 96.73,42.7 98.32,44.29 101.01,44.29 110.43,53.7 110.8,53.7 115.9,58.8 117.49,58.8 119.56,60.87 123.24,60.87 126.78,64.41 126.78,66.72 128.61,68.56 131.62,68.56 132.67,69.61 143.8,69.61 151.15,76.97 154.61,76.97 v1(154.86,77.22)
  IN4 w0.06: v8(53.64,57.65) 53.64,57.37 53.84,57.17 53.84,57 53.72,56.89 53.72,56.03 54.99,54.76
  IN4 w0.064: 54.99,54.76 55.01,54.74 55.01,54.54 v11(55.09,54.46)
SDIO2_DATA3: length 126.6
  IN3 w0.06: 55.62,54.69 55.57,54.74 55.57,54.89 53.25,57.21 53.25,58.09 53.27,58.12 53.27,58.26 53.25,58.33 53.14,58.44 53.14,58.72 v8(53.07,58.79)
  IN3 w0.064: 55.62,54.69 55.62,54.03 56.61,53.04 56.61,52.76 62.85,46.53 65.14,46.53 66.43,45.24 69.78,45.24 70.69,44.33 80.84,44.33 81.76,43.41 96.44,43.41 98.02,45 100.69,45 110.11,54.41 110.51,54.41 115.61,59.51 117.12,59.51 119.26,61.66 123,61.66 126.07,64.73 126.07,67.04 128.29,69.27 131.17,69.27 132.23,70.32 142.34,70.32 150.55,78.54 155.34,78.54 v1(155.76,78.12)
SDIO3_1.8_EN#: length 13.4
  IN3 w0.06: v8(56.75,57.94) 56.75,57.85 57.17,57.44 60.5,57.44 60.94,57 60.98,57
  IN3 w0.064: v1(66.57,56.69) 66.46,56.81 62.57,56.81 62.37,57 60.98,57
  BOTTOM w0.114: v1(66.57,56.69) 66.75,56.52 66.75,56.25 66.96,56.03 68.44,56.03 PR70.1
SDIO3_1.8_EN#_R: length 21.3
  IN3 w0.06: 82.5,60.22 82.5,60.94 83.87,62.31 83.87,62.54 v8(84.48,63.15) ; 81.33,59.06 81.33,58.93
  IN3 w0.064: 82.5,60.22 81.33,59.06 ; 81.33,58.93 81.33,58.57 80.97,58.22 78.94,58.22 78.13,57.41 78.13,55.98 77.82,55.67 75.43,55.67 75.17,55.41 74.43,55.41 73.54,54.52 71.29,54.52 70.3,55.5 v1(70.3,55.98)
  BOTTOM w0.114: PR70.2 70.1,56.54 70.3,56.34 v1(70.3,55.98)
SDIO3_CD: length 3.7
  TOP w0.114: Q11.3 126.4,59.64 R182.2 126.37,59.62 125.98,59.62 125.75,59.84 Q11.2
SDIO3_CD#: length 120.2
  TOP w0.114: R183.1 T10.1 126.73,65.14 126.26,64.67 125.45,64.67 v5(125.12,64.34) 125.32,64.14 125.52,64.14 125.75,63.91 Q11.5 ; v5(138.99,73.41) 139.31,73.09 CN4.9
  IN2 w0.064: v5(138.99,73.41) 136.99,73.41 136.72,73.14 127.8,73.14 126.23,71.58 126.23,68.58 125.19,67.54 125.19,64.42 v5(125.12,64.34) 125.12,64.26 124.58,63.73 122.56,63.73 122.28,64.01 121.76,64.01 118.01,67.77 115.06,67.77 v4(115.03,67.79)
  IN3 w0.06: 57.41,54.14 57.32,54.24 57.1,54.24 56.82,54.52 56.82,54.97 54.49,57.29 v8(54.49,57.94)
  IN3 w0.064: v4(115.03,67.79) 115.01,67.77 114.75,67.77 112.58,65.59 111.45,65.59 110.89,65.04 110.89,64.59 110.94,64.54 110.94,56.16 110.12,55.34 109.72,55.34 103.76,49.37 102.28,49.37 99.17,46.27 96.86,46.27 96.28,45.68 91.84,45.68 91.67,45.51 89.73,45.51 89.52,45.3 81.92,45.3 81.58,45.65 80.36,45.65 79.73,46.29 73.76,46.29 72.7,47.35 71.83,47.35 71.02,48.16 67.19,48.16 64.71,50.64 64.49,50.64 63.38,51.75 63.38,52.88 62.77,53.48 60.13,53.48 59.47,54.14 57.42,54.14 57.41,54.14
SDIO3_CLK: length 114.6
  TOP w0.114: v5(135.79,71.02) 135.01,71.8 CN4.5
  IN2 w0.064: v5(135.79,71.02) 135.79,70.69 135.33,70.23 133.37,70.23 132.79,70.82 132.79,71.1 132.69,71.2 132.13,71.2 132,71.07 132,70.79 131.24,70.03 129.93,70.03 126.39,66.49 126.39,60.71 125.14,59.46 v4(125.14,58.7)
  IN3 w0.06: v8(52.79,58.5) 52.79,58.39 52.73,58.33 52.73,58.16 52.59,58.02 52.59,57.85 52.65,57.79 52.65,57.05 53.41,56.29 53.41,55.17 54.02,54.56 54.02,54.21 55.29,52.94 55.29,52.91
  IN3 w0.064: v4(125.14,58.7) 124.25,57.81 120.47,57.81 119.95,57.29 119.28,57.29 117.66,55.67 117.66,53.19 116.84,52.36 116.84,51.15 116.16,50.47 112.57,50.47 112,51.04 109.46,51.04 107.14,48.73 106.79,48.73 101.63,43.58 98.61,43.58 97.01,41.98 81.18,41.98 80.25,42.91 69.97,42.91 69.06,43.82 65.72,43.82 64.45,45.09 61.37,45.09 55.29,51.17 55.29,52.91
SDIO3_CMD: length 109.9
  TOP w0.114: T13.1 133.21,70.97 CN4.3
  IN2 w0.064: v5(133.22,70.92) 132.76,71.38 132.03,71.38 131.75,71.1 131.75,70.79 131.22,70.26 129.85,70.26 126.21,66.62 126.21,60.78 124.74,59.31 v4(124.74,59.11)
  IN3 w0.06: 55.5,52.91 55.5,52.94 54.33,54.1 54.33,55.62 52.79,57.16 v8(52.79,57.94)
  IN3 w0.064: v4(124.74,59.11) 124.69,59.06 124.69,58.6 124.08,57.99 120.39,57.99 119.86,57.47 119.21,57.47 117.48,55.74 117.48,53.26 116.66,52.43 116.66,51.22 116.08,50.65 112.64,50.65 112.07,51.22 109.35,51.22 107.11,48.97 106.78,48.97 101.56,43.75 98.54,43.75 96.94,42.15 81.26,42.15 80.32,43.09 70.05,43.09 69.14,43.99 65.8,43.99 64.53,45.26 61.45,45.26 55.5,51.22 55.5,52.91
SDIO3_DATA_0: length 114.4
  TOP w0.114: v5(136.83,70.94) 136.81,70.96 CN4.7
  IN2 w0.064: v4(125.65,57.86) 125.65,58.35 126.92,59.62 126.92,66.01 130.38,69.47 135.35,69.47 v5(136.83,70.94)
  IN3 w0.06: 54.68,52.91 54.38,53.21 v11(54.28,53.21)
  IN3 w0.064: 54.68,52.91 54.72,52.87 54.72,50.98 61.15,44.55 64.23,44.55 65.5,43.28 68.72,43.28 69.62,42.38 80.03,42.38 80.96,41.44 97.23,41.44 98.83,43.04 101.96,43.04 107.08,48.16 107.33,48.16 109.67,50.49 111.79,50.49 112.35,49.94 116.38,49.94 117.37,50.93 117.37,52.14 118.2,52.97 118.2,55.45 119.5,56.76 120.2,56.76 120.67,57.23 125.02,57.23 v4(125.65,57.86)
  IN4 w0.06: 54.38,53.85 53.32,54.9 53.32,55.67 52.87,56.11 52.87,56.53 53.03,56.68 53.03,56.85 52.87,57.01 52.87,57.17 53.07,57.37 v8(53.07,57.65)
  IN4 w0.07: 54.38,53.85 54.38,53.32 v11(54.28,53.21)
SDIO3_DATA_1: length 116
  TOP w0.114: CN4.8 137.71,70.96 v5(137.69,70.94)
  IN2 w0.064: v5(137.69,70.94) 137.44,71.2 136.57,71.2 135.02,69.65 130.31,69.65 126.74,66.08 126.74,59.74 126.16,59.16 v4(125.55,59.16)
  IN3 w0.06: 55.08,52.91 55.08,52.98 54.97,53.09 54.94,53.09 53.84,54.18 53.84,54.41 53.29,54.97 53.29,56.25 52.53,57 52.53,57.74 52.47,57.8 52.47,58.07 52.59,58.19 52.59,58.7 v8(52.51,58.79)
  IN3 w0.064: v4(125.55,59.16) 125.55,58.55 124.63,57.63 120.55,57.63 120.03,57.11 119.36,57.11 117.84,55.6 117.84,53.11 117.01,52.29 117.01,51.08 116.23,50.29 112.49,50.29 111.92,50.87 109.53,50.87 107.18,48.52 106.85,48.52 101.74,43.4 98.69,43.4 97.09,41.8 81.11,41.8 80.17,42.73 69.9,42.73 68.99,43.64 65.65,43.64 64.38,44.91 61.3,44.91 55.08,51.13 55.08,52.91
SDIO3_DATA_2: length 108.4
  TOP w0.114: v5(131.47,70.93) 131.41,70.99 CN4.1
  IN2 w0.064: v4(124.25,58.75) 124.25,60.15 126.03,61.93 126.03,66.69 129.78,70.44 130.97,70.44 v5(131.47,70.93)
  IN3 w0.06: 55.7,52.91 54.51,54.1 54.51,55.61 52.99,57.13 52.99,58.02 52.87,58.14 52.87,58.3 52.99,58.42 52.99,58.59 52.79,58.79 v8(52.79,59.07)
  IN3 w0.064: v4(124.25,58.75) 123.67,58.17 120.31,58.17 119.79,57.65 119.14,57.65 117.31,55.82 117.31,53.33 116.48,52.51 116.48,51.3 116.01,50.83 112.71,50.83 112.14,51.4 109.28,51.4 107.12,49.24 106.79,49.24 101.48,43.93 98.47,43.93 96.86,42.33 81.33,42.33 80.4,43.26 70.12,43.26 69.21,44.17 65.87,44.17 64.6,45.44 61.52,45.44 55.7,51.26 55.7,52.91
SDIO3_DATA_3: length 108.8
  TOP w0.114: v5(132.33,70.94) 132.31,70.97 CN4.2
  IN2 w0.064: v5(132.33,70.94) 132.33,70.82 131.34,69.83 130.05,69.83 126.56,66.34 126.56,60.33 v4(125.88,59.64)
  IN3 w0.06: v11(54.12,53.54) 54.3,53.54 54.9,52.95 54.9,52.91
  IN3 w0.064: v4(125.88,59.64) 125.93,59.59 125.93,58.65 124.69,57.41 120.57,57.41 120.1,56.94 119.43,56.94 118.02,55.52 118.02,53.04 117.19,52.21 117.19,51 116.3,50.12 112.42,50.12 111.85,50.69 109.61,50.69 107.26,48.34 106.96,48.34 101.84,43.22 98.76,43.22 97.16,41.62 81.03,41.62 80.1,42.55 69.83,42.55 68.92,43.46 65.58,43.46 64.31,44.73 61.23,44.73 54.9,51.06 54.9,52.91
  IN4 w0.06: v8(52.83,56.77) 52.83,56.65 52.76,56.58 52.76,55.98 53.18,55.55 53.18,54.87 54.12,53.93
  IN4 w0.07: v11(54.12,53.54) 54.12,53.93
SDIO3_PWR_EN#: length 12.8
  IN3 w0.06: 60.98,56.85 60.86,56.85 60.39,57.32 57.05,57.32 56.55,57.81 56.55,58.02 56.67,58.14 56.67,58.3 56.47,58.5 v8(56.47,58.79)
  IN3 w0.064: v1(66.44,56.36) 66.15,56.65 62.51,56.65 62.31,56.85 60.98,56.85
  BOTTOM w0.114: v1(66.44,56.36) 66.44,56.16 67.03,55.58 PR71.1
SDIO3_PWR_EN#_R: length 19.3
  IN3 w0.064: v1(70.61,55.65) 71.59,54.67 73.48,54.67 74.37,55.56 75.07,55.56 75.33,55.82 77.66,55.82 77.97,56.14 77.97,58.12 78.61,58.75 v11(79.12,58.75)
  IN4 w0.06: 81.35,61.08 81.61,61.08 v8(82.08,61.55)
  IN4 w0.127: 81.35,61.08 80.07,61.08 79.12,60.12 v11(79.12,58.75)
  BOTTOM w0.114: PR71.2 70.53,55.58 v1(70.61,55.65)
SDIO3_RCOMP: length 1.4
  TOP w0.114: R39.2 52.47,59.29 v5(52.5,59.31)
  IN2 w0.114: v12(52.51,59.74) 52.51,59.72 52.5,59.71 52.5,59.36 v5(52.5,59.31)
  IN3 w0.127: v12(52.51,59.74) v8(52.51,59.35)
SDWN#_R: length 10.1
  IN2 w0.064: v4(79.57,58.73) 79.91,58.4 v5(79.91,58.19)
  IN3 w0.064: v4(79.57,58.73) 79.3,58.45 v11(78.69,58.45)
  IN4 w0.06: v8(83.68,62.75) 83.68,62.75 83.88,62.55 83.88,62.26 83.62,62 83.44,62 83.18,61.75 81.99,61.75 81.97,61.72 81.86,61.72 81.63,61.49 81.63,61.37 81.58,61.32 81.35,61.32
  IN4 w0.127: v11(78.69,58.45) 78.69,60.1 79.91,61.32 81.35,61.32
SEC_JTAG_EN#: length 20.8
  TOP w0.114: CN1.5 54.62,73.04 53.69,72.11 49.93,72.11 49.3,72.75 49.3,73.05 v5(49.25,73.1)
  IN2 w0.064: v5(49.25,73.1) 47.9,73.1 46.35,74.65 46.35,77.75 46.89,78.28 48.43,78.28 v5(48.78,78.64) 48.38,78.64 47.88,79.14 v5(47.78,79.14) 48.08,79.44 48.08,79.76 47.9,79.94 v5(45.41,79.94)
SENSOR_HUB_INT: length 95.7
  IN2 w0.064: v5(49.43,75.03) 49.73,75.34 49.73,77.17 49.58,77.32 49.58,78.84 v5(49.28,79.14) 48.92,79.14 48.54,79.53 48.54,79.54 48.53,79.54 48.53,79.74 48.54,79.74 48.54,79.86 49.23,80.55 50.69,80.55 50.86,80.72 51.91,80.72 51.93,80.74 56.7,80.74 58.29,79.15 62.9,79.15 63.2,78.84 63.2,77.4 63.69,76.91 64.89,76.91 65.42,77.44 68.28,77.44 68.42,77.3 69.92,77.3 70.35,76.86 79.5,76.86 81.21,75.15 v4(84.55,75.15) ; v12(79.75,69.04) 79.75,68.78 79.22,68.25 78.69,68.25 78.26,67.83 78.26,65.67 78.6,65.33 79.46,65.33 79.83,64.96 79.83,63.07 79.64,62.89 79.64,61.22 78.74,60.31 78.74,58.9 79.96,57.68 79.96,54.87 83.73,51.09 83.73,49.16 v4(84.17,48.72)
  IN3 w0.064: v4(84.17,48.72) 84.38,48.52 89.07,48.52 89.3,48.74 92.5,48.74 v1(92.71,48.54) ; v4(84.55,75.15) 84.36,74.96 84.36,71.63 82.02,69.29 80,69.29 v12(79.75,69.04)
  BOTTOM w0.114: R335.1 92.15,48 92.15,46.13 91,44.98 91,43.96 91.38,43.59 91.9,43.59 92.34,44.04 Q17.2
SENSOR_HUB_INT_3P3: length 4.9
  IN2 w0.064: v5(91.39,43.79) 91.79,43.79 v4(91.84,43.84)
  IN3 w0.064: v1(92.86,43.74) 92.76,43.84 v4(91.84,43.84)
  BOTTOM w0.114: R336.1 Q17.3 91.97,43.26 92.33,43.61 92.73,43.61 v1(92.86,43.74)
SENSOR_HUB_RST: length 5.9
  TOP w0.114: Q10.3 101.35,43.83 101.49,43.69 101.85,43.69 102,43.84 ; 102,43.84 Q10.2 ; 102,43.84 102.16,43.69 102.89,43.69 103.02,43.82 103.02,45.57 102.58,46.01 R160.2
SENSOR_HUB_RST#: length 84.1
  TOP w0.114: v5(103.02,35.71) 103.1,35.79 103.1,41.33 102.99,41.43 102.1,41.43 102,41.53 Q10.5
  IN2 w0.064: v5(103.02,35.71) 103.02,35.56 v4(102.49,35.03)
  IN3 w0.06: 50.9,54.59 50.9,55.98 50.03,56.85 50.03,57.58 49.88,57.74 49.76,57.85 49.76,57.86 49.76,57.86 49.76,58.01 49.88,58.14 49.88,58.3 49.76,58.42 49.76,58.59 49.96,58.79 v8(49.96,59.07)
  IN3 w0.064: 50.9,54.59 50.9,52.1 50.72,51.92 50.72,49.84 48.5,47.61 48.5,42.87 49.92,41.44 54.03,41.44 54.66,40.81 63.56,40.81 64.38,39.98 66.83,39.98 72.2,34.61 81.06,34.61 81.33,34.88 102.33,34.88 v4(102.49,35.03)
SENSOR_HUB_RST_3P3_R: length 70.7
  TOP w0.114: v5(61.31,71.38) 61.31,71.75 61.35,71.78 R75.1 ; U10.7 99.21,41.3 100.06,42.15 C106.1 100.47,42.15 100.73,42.42 100.73,43.21 100.89,43.36 102.49,43.36 102.65,43.19 Q10.6 103.27,42.44 103.37,42.53 R157.2
  IN2 w0.064: v5(97.91,41.3) 95.96,41.3 95.45,41.81 95.45,44.6 95.15,44.91 92.76,44.91 v4(91.08,46.59) ; v5(61.31,71.38) 61.39,71.38 61.54,71.23 61.88,71.23 62.45,70.66 63.09,70.66 65.79,67.97 68.27,67.97 68.65,67.59 68.65,66.9 69.08,66.47 69.98,66.47 70.71,65.74 70.71,65.46 71.32,64.85 71.32,61.63 71.03,61.34 71.03,59.84 70.19,59 70.19,54.87 71.03,54.03 71.03,50.84 v4(71.29,50.57)
  IN3 w0.064: v4(91.08,46.59) 90.4,47.27 87.06,47.27 86.03,46.24 85.08,46.24 83.93,47.39 74.32,47.39 72.79,48.92 72.79,49.55 71.76,50.57 v4(71.29,50.57)
SENSOR_HUB_WAKE: length 37.2
  TOP w0.114: v5(84.83,44.3) 85.11,44.58 Q9.5
  IN2 w0.064: v5(84.83,44.3) 84.15,44.3 82.7,45.75 v4(82.7,46.08)
  IN3 w0.064: v4(82.7,46.08) 82.55,46.22 80.6,46.22 79.97,46.86 74.06,46.86 71.62,49.3 69.56,49.3 69.25,49.61 67.82,49.61 67.62,49.82 66.77,49.82 64.87,51.72 v11(64.67,51.72)
  IN4 w0.06: 57.43,54.59 56.13,55.88 56.13,56.54 55.99,56.69 55.99,56.89 56.1,57.01 56.1,57.17 55.9,57.37 55.9,57.38 v8(55.9,57.65)
  IN4 w0.127: v11(64.67,51.72) 64.54,51.84 62.07,51.84 61.48,52.44 60.56,52.44 58.48,54.52 57.49,54.52 57.43,54.59
SENSOR_HUB_WAKE#: length 5.5
  TOP w0.114: Q9.2 85.11,46.92 85.03,46.83 84.6,46.83 84.46,46.98 Q9.3 84.46,48.61 84.27,48.79 83.44,48.79 83.28,48.64 R115.2
SENSOR_HUB_WAKE_3P3: length 20.5
  TOP w0.114: R116.2 85.96,45.74 Q9.6
  IN2 w0.064: v5(98.02,42.8) 96.72,42.8 96.36,43.16 96.36,45.29 96.85,45.77 96.85,46.64 96.8,46.69 95.44,46.69 94.76,47.36 94.76,47.91 v4(93.88,48.79) ; v4(87.65,49.18) 87.65,48.34 86.89,47.58 86.89,46.66 v5(86.74,46.51)
  IN3 w0.064: v4(87.65,49.18) 88.01,48.82 88.95,48.82 89.18,49.05 93.62,49.05 v4(93.88,48.79)
SIM_CLK: length 149.7
  TOP w0.114: v5(114.53,69.24) 114.95,69.66 T7.2 114.71,69.91 J1.5
  IN2 w0.064: v4(107.24,67.36) 107.62,66.98 108.83,66.98 109.47,67.62 112.91,67.62 v5(114.53,69.24) ; v4(91.61,52.68) 91.18,52.68 89.71,51.21 89.71,46.36 89.3,45.94 89.3,42.51 88.44,41.65 88.44,38.66 85.04,35.26 61.93,35.26 61.27,35.92 60.22,35.92 59.56,35.26 43.31,35.26 38.18,30.13 35.37,30.13 30.2,24.95 30.2,21.82 28.65,20.27 28.65,15.95 31.57,13.03 36.39,13.03 37.06,12.37 37.06,10.67 36.73,10.34 30.5,10.34 v4(30.48,10.31)
  IN3 w0.064: v1(29.79,5.89) 29.79,6.22 30.04,6.48 30.04,9.98 v1(30.12,10.06) 30.38,10.31 v4(30.48,10.31) ; v4(107.24,67.36) 107.24,67.87 106.98,68.12 105.58,68.12 104.37,66.91 101.6,66.91 99.72,65.03 99.13,65.03 98.75,64.64 98.75,61.14 98.88,61.01 98.88,59.72 92.05,52.88 91.82,52.88 v4(91.61,52.68)
SIM_DATA: length 152.4
  TOP w0.114: J1.4 115.41,70.89 115.85,70.45 T8.2 115.81,69.66 v5(115.41,69.27)
  IN2 w0.064: v5(115.41,69.27) 114.96,69.27 113.1,67.41 109.56,67.41 108.91,66.75 107.51,66.75 107.29,66.98 106.75,66.98 v4(106.35,67.39) ; v4(29.11,10.52) 29.66,9.96 30.76,9.96 30.91,10.11 36.98,10.11 37.28,10.42 37.28,12.57 36.6,13.26 31.7,13.26 28.88,16.08 28.88,20.17 30.43,21.72 30.43,24.86 35.46,29.9 38.27,29.9 43.4,35.03 85.24,35.03 88.69,38.48 88.69,41.6 89.51,42.42 89.51,45.63 89.94,46.05 89.94,51.08 91.18,52.33 91.89,52.33 92.29,52.72 v4(92.38,52.72)
  IN3 w0.064: v1(29.31,5.87) 29.31,6.58 29.13,6.76 29.13,9.83 29.23,9.93 v1(29.23,10.06) 29.11,10.19 v4(29.11,10.52) ; v4(106.35,67.39) 106.32,67.41 105.18,67.41 104.32,66.55 101.65,66.55 99.87,64.77 99.29,64.77 99.01,64.49 99.01,61.19 99.11,61.09 99.11,59.59 92.38,52.86 v4(92.38,52.72)
  BOTTOM w0.114: C187.1 R257.2
SIM_PWR: length 4.7
  TOP w0.508: L2.1 C114.2 C109.2 110.51,69.99 111.07,70.56 111.34,70.56 111.91,71.12 J1.9
SIM_RST: length 148.3
  TOP w0.114: J1.7 113.31,69.79 T6.2 113.6,69.24 v5(113.64,69.24)
  IN2 w0.064: v4(107.95,67.74) 107.95,67.69 108.43,67.21 108.75,67.21 109.38,67.84 112.59,67.84 113.64,68.89 v5(113.64,69.24) ; v4(91.84,53.24) 91.28,53.24 89.23,51.18 89.23,46.23 89.08,46.08 89.08,42.78 88.21,41.91 88.21,38.94 84.76,35.49 80.5,35.49 79.85,36.13 75.75,36.13 75.62,36 61.5,36 61.36,36.13 60.11,36.13 59.51,35.54 43.28,35.54 38.12,30.38 35.23,30.38 29.97,25.12 29.97,21.92 28.42,20.37 28.42,15.85 31.52,12.75 36.14,12.75 36.7,12.19 36.7,10.77 36.5,10.57 31.39,10.57 v4(31.26,10.69)
  IN3 w0.064: v4(91.84,53.24) 91.94,53.24 98.65,59.95 98.65,60.81 98.52,60.94 98.52,64.95 98.83,65.25 99.62,65.25 101.55,67.18 104.25,67.18 105.47,68.4 107.29,68.4 v4(107.95,67.74) ; v1(30.3,5.87) 30.3,9.04 31.01,9.76 v1(31.01,10.06) 31.01,10.19 31.26,10.44 v4(31.26,10.69)
SIM_VCC: length 146.6
  TOP w0.508: 112.42,68.2 118.08,68.2 118.51,68.63 R178.2
  IN2 w0.508: v4(42.03,32.74) 42.03,33 43.58,34.55 85.42,34.55 89.18,38.3 89.18,41.43 89.98,42.23 89.98,45.35 90.45,45.82 90.45,50.93 v4(91.36,51.84) ; v5(112.29,68.82) v5(112.29,68.3) 109.19,68.3 v4(108.61,67.72)
  IN3 w0.381: v1(28.34,10.82) 28.22,10.69 28.22,8.46 28.72,7.95 28.72,5.95 v1(28.8,5.87)
  IN3 w0.508: v1(28.34,10.82) 28.72,11.2 28.72,12.37 25.22,15.88 25.22,29.39 28.42,32.59 34.03,32.59 35.48,31.14 40.43,31.14 v4(42.03,32.74) ; v4(91.36,51.84) 92.58,51.84 100,59.26 100,61.44 99.62,61.83 99.62,63.25 102.41,66.04 107.05,66.04 108.61,67.6 v4(108.61,67.72)
SLP_S0IX#: length 190.1
  TOP w0.114: v5(55.75,81.54) 55.75,78.79 55.98,78.56 v5(56.77,78.56) 57.2,78.56 57.48,78.28 58.21,78.28 58.44,78.06 R69.2 ; R180.1 120.97,62.6 120.82,62.75 v5(120.58,62.75) ; v13(81.68,74.45) 80.92,74.45 80.73,74.64 Q6.1 80.85,74.94 v5(81.78,75.87)
  IN2 w0.064: v5(56.77,78.56) 56.74,78.54 56.23,78.54 55.78,78.08 55.78,77.57 55.85,77.5 55.85,76.73 v12(55.83,76.71) ; v4(85.19,75.54) 85.02,75.71 81.95,75.71 v5(81.78,75.87) ; v5(120.58,62.75) 120.85,63.02 120.85,63.8 117.94,66.71 112.07,66.71 111.37,66.02 109.55,66.02 109.32,65.79 105.96,65.79 105.12,66.63 99.47,66.63 97.69,68.41 97.69,68.98 94.1,72.56 91,72.56 90.73,72.29 84.58,72.29 81.58,69.29 81,69.29 v12(80.67,68.96) ; v4(22.86,50.88) 24.25,52.27 24.25,81.15 25.27,82.17 46.91,82.17 47.62,81.46 55.67,81.46 v5(55.75,81.54) 56.86,81.54 58.58,79.82 66.2,79.82 66.44,79.58 69.31,79.58 69.98,78.91 69.98,78.46 70.72,77.73 79.96,77.73 80.67,78.44 83.07,78.44 83.5,78 85.06,78 v4(85.16,77.9)
  IN3 w0.06: 53.72,71.78 53.72,70.02 v8(53.92,69.82)
  IN3 w0.064: v11(81.25,65.03) 81.15,65.03 80.46,65.71 80.46,67.74 80.62,67.9 80.62,68.25 80.44,68.43 80.44,68.73 v12(80.67,68.96) 80.67,68.48 80.84,68.3 81.06,68.3 81.61,68.85 81.85,68.85 84.55,71.55 84.55,74.65 85.19,75.29 v4(85.19,75.54) 85.16,75.57 v4(85.16,77.9) ; v12(55.83,76.71) 55.75,76.71 54.94,75.9 54.94,74.22 54.63,73.92 54.1,73.92 53.82,73.64 53.82,72.09 53.72,71.99 53.72,71.78 ; v1(19.33,48.25) 19.9,48.25 20.55,48.9 21,48.9 21.1,48.79 21.7,48.79 22.86,49.95 v4(22.86,50.88)
  IN4 w0.06: 81.35,64.92 81.37,64.91 81.47,64.91 81.81,64.57 82.17,64.57 82.39,64.35 v8(82.48,64.35)
  IN4 w0.064: v11(81.25,65.03) 81.35,64.92
SLP_S3#: length 117
  TOP w0.114: v5(120.57,63.73) 120.97,63.34 R179.1 ; v5(92.66,79.94) 92.66,76.66 92.35,76.35 v13(92.35,72.92) 92.35,72.62 v5(92.66,72.32) ; v5(55.11,83.16) 55.11,81.64 55.32,81.43 55.32,78.56 v5(55.6,78.28) 55.62,78.31 56.23,78.31 56.75,77.79 R55.2
  IN2 w0.064: v5(55.11,83.16) 56.24,83.16 58.83,80.57 66.42,80.57 67.26,81.41 69.08,81.41 70.52,79.98 70.52,78.68 70.94,78.26 79.74,78.26 80.45,78.97 83.29,78.97 83.61,78.65 86.32,78.65 87.06,79.39 92.11,79.39 v5(92.66,79.94) ; v12(81.18,68.96) 81.51,68.96 84.29,71.74 85.43,71.74 85.78,72.1 91.43,72.1 91.65,72.32 v5(92.66,72.32) 94.1,72.32 97.38,69.03 97.38,68.47 99.4,66.45 105.05,66.45 105.89,65.61 109.4,65.61 109.63,65.84 111.45,65.84 112.15,66.54 117.86,66.54 120.57,63.83 v5(120.57,63.73) ; v5(55.6,78.28) 55.6,77.29 v12(55.52,77.22)
  IN3 w0.064: v12(81.18,68.96) 80.97,68.76 v11(80.97,68.58) ; v12(55.52,77.22) 55.29,77.22 54.99,76.92 54.99,76.69 54.75,76.44 54.75,74.44 v11(54.51,74.19)
  IN4 w0.06: v8(53.64,71.24) 53.64,71.76 54.33,72.45 54.33,74.02 v11(54.51,74.19) ; 81.35,65.53 81.94,64.95 82.98,64.95 83.08,64.85 83.08,64.55 v8(83.28,64.35)
  IN4 w0.064: v11(80.97,68.58) 80.97,68.56 80.87,68.45 80.87,66.02 81.35,65.53
