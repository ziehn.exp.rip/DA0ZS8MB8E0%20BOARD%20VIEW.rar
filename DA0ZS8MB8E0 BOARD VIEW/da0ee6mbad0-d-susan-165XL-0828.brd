# Allegro board da0ee6mbad0-d-susan-165XL-0828.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
M_0_CKE2: length 35.9
  IN2 w0.064: v12(33.5,73.79) 33.27,73.56 33.27,73.13 34.44,71.96 34.44,66.3 34.52,66.22 34.68,66.22 34.76,66.3 34.76,66.73 34.83,66.8 35,66.8 35.07,66.73 35.07,66.3 35.15,66.22 35.32,66.22 35.39,66.3 35.39,66.73 35.47,66.8 35.63,66.8 35.71,66.73 35.71,66.3 35.79,66.22 35.95,66.22 36.03,66.3 36.03,66.73 36.1,66.8 36.27,66.8 36.34,66.73 36.34,66.3 36.42,66.22 36.59,66.22 36.66,66.3 36.66,66.73 36.74,66.8 36.9,66.8 36.98,66.73 36.98,66.3 37.06,66.22 37.22,66.22 37.3,66.3 37.3,66.73 37.37,66.8 37.54,66.8 37.61,66.73 37.61,66.3 37.69,66.22 37.86,66.22 37.93,66.3 37.93,66.73 38.01,66.8 38.17,66.8 38.25,66.73 38.25,66.3 38.33,66.22 38.49,66.22 38.57,66.3 38.57,66.73 38.64,66.8 38.81,66.8 38.88,66.73 38.88,66.3 38.96,66.22 39.13,66.22 39.2,66.3 39.2,66.73 39.28,66.8 39.44,66.8 39.52,66.73 39.52,66.3 39.6,66.22 39.76,66.22 39.84,66.3 39.84,66.73 39.91,66.8 40.08,66.8 40.15,66.73 40.15,66.3 40.23,66.22 40.4,66.22 40.47,66.3 40.47,66.73 40.55,66.8 40.71,66.8 40.79,66.73 40.79,66.3 40.87,66.22 41.03,66.22 41.11,66.3 41.11,66.73 41.18,66.8 41.37,66.8 41.45,66.73 41.45,66.32 41.53,66.24 41.72,66.24 41.79,66.32 41.79,70.09 v12(42.29,70.59)
  IN3 w0.06: v11(42.72,70.59) v12(42.29,70.59) ; v8(31.51,74.31) 31.58,74.31 32.28,73.61 33.32,73.61 v12(33.5,73.79)
  IN4 w0.06: v8(44.59,69.54) 44.3,69.54 43.99,69.85 43.91,69.85 43.18,70.59 v11(42.72,70.59)
M_0_CKE3: length 35.9
  IN2 w0.064: v12(34.01,73.69) 34.01,73.31 34.08,73.23 35.2,73.23 35.28,73.15 35.28,69.32 35.35,69.24 35.52,69.24 35.59,69.32 35.59,70.66 35.67,70.74 35.84,70.74 35.91,70.66 35.91,69.32 35.99,69.24 36.15,69.24 36.23,69.32 36.23,70.66 36.31,70.74 36.47,70.74 36.55,70.66 36.55,69.32 36.62,69.24 36.79,69.24 36.86,69.32 36.86,70.66 36.94,70.74 37.11,70.74 37.18,70.66 37.18,69.29 37.26,69.22 37.42,69.22 37.5,69.29 37.5,70.66 37.58,70.74 37.92,70.74 38,70.66 38,70.23 38.07,70.16 38.24,70.16 38.31,70.23 38.31,70.66 38.39,70.74 38.55,70.74 38.63,70.66 38.63,69.29 38.71,69.22 38.87,69.22 38.95,69.29 38.95,70.66 39.02,70.74 39.19,70.74 39.27,70.66 39.27,69.32 39.34,69.24 39.51,69.24 39.58,69.32 39.58,70.66 39.66,70.74 39.82,70.74 39.9,70.66 39.9,69.34 39.98,69.27 40.48,69.27 40.56,69.34 v12(40.56,70.56)
  IN3 w0.06: v8(34.01,75.81) v12(34.01,73.69)
  IN3 w0.064: v11(40.97,70.56) v12(40.56,70.56)
  IN4 w0.06: 42.14,70.97 43.68,70.97 v8(43.95,71.24)
  IN4 w0.064: v11(40.97,70.56) 41.37,70.97 42.14,70.97
M_0_CLKN0: length 32.6
  IN2 w0.083: v12(31.21,73.41) 31.21,73.51 31.14,73.59 30.93,73.59 30.86,73.51 30.86,73.26 30.71,73.11 30.71,72.87 31.33,72.25 32.42,72.25 33.12,71.54 33.12,71.19 v5(33.37,70.94) 33.15,70.72 33.15,70.42 32.78,70.05 30.6,70.05 30.4,69.85 30.4,66.83 30.76,66.47 30.76,65.36 31.21,64.9 41.05,64.9 41.49,65.34 42.24,65.34 43.55,66.64 43.55,69.63 v12(43.25,69.93)
  IN3 w0.06: v11(43.24,69.52) 43.28,69.56 43.28,69.9 v12(43.25,69.93) ; v12(31.21,73.41) 31.01,73.61 v8(31.01,73.81)
  IN4 w0.06: v8(44.3,68.69) 44.3,68.69 44.3,68.74 44.2,68.84 44.02,68.84 43.72,69.14 43.61,69.14 43.24,69.51 v11(43.24,69.52)
M_0_CLKN2: length 32.6
  IN2 w0.083: v12(32.92,74.91) 32.92,74.55 v5(32.84,74.47) 32.97,74.35 32.97,74.01 32.73,73.78 32.73,72.76 33.8,71.68 33.8,70.41 32.96,69.56 31.58,69.56 31.26,69.23 31.26,66.89 31.44,66.71 31.44,65.59 31.73,65.3 40.92,65.3 41.3,65.69 42.08,65.69 42.74,66.35 v12(42.74,69.93)
  IN3 w0.06: v12(42.74,69.93) 42.64,69.83 42.64,69.65 v11(42.77,69.52) ; v8(33.51,76.81) 33.27,76.57 33.27,75.48 33.14,75.35 33.14,75.26 32.92,75.03 v12(32.92,74.91)
  IN4 w0.06: v8(44.59,68.41) 44.51,68.41 44.45,68.47 44.1,68.47 43.59,68.98 42.88,68.98 42.64,69.22 42.64,69.39 v11(42.77,69.52)
M_0_CLKP0: length 32.6
  IN2 w0.083: v12(30.5,73.41) 30.55,73.36 30.55,72.8 31.27,72.09 32.36,72.09 32.97,71.48 32.97,71.15 v5(32.76,70.94) 32.99,70.72 32.99,70.49 32.72,70.21 30.54,70.21 30.24,69.92 30.24,66.76 30.6,66.41 30.6,65.29 31.14,64.75 41.12,64.75 41.55,65.18 42.31,65.18 43.71,66.58 43.71,69.88 v12(43.76,69.93)
  IN3 w0.06: v11(43.58,69.52) 43.58,69.75 v12(43.76,69.93) ; v8(30.51,73.81) 30.51,73.41 v12(30.5,73.41)
  IN4 w0.06: v11(43.58,69.52) 43.58,69.34 43.66,69.26 43.77,69.26 44.07,68.96 44.31,68.96 44.57,68.71 44.85,68.71 v8(44.87,68.69)
M_0_CLKP2: length 32.6
  IN2 w0.083: v12(33.42,74.91) 33.42,74.5 v5(33.45,74.47) 33.12,74.15 33.12,73.95 32.89,73.71 32.89,72.82 33.96,71.75 33.96,70.34 33.02,69.4 31.65,69.4 31.42,69.17 31.42,66.95 31.59,66.77 31.59,65.66 31.8,65.46 40.85,65.46 41.24,65.84 42.02,65.84 42.59,66.41 42.59,69.58 v12(42.24,69.93)
  IN3 w0.06: v12(33.42,74.91) 33.42,74.96 33.26,75.12 33.26,75.3 33.39,75.43 33.39,76.19 v8(33.51,76.31) ; v11(42.39,69.52) 42.44,69.57 42.44,69.7 42.24,69.9 v12(42.24,69.93)
  IN4 w0.06: v8(45.15,68.41) 44.87,68.41 44.67,68.21 44.5,68.21 44.36,68.35 44.05,68.35 43.54,68.86 42.83,68.86 42.52,69.17 42.52,69.39 v11(42.39,69.52)
M_0_CS0#: length 43
  IN2 w0.089: v12(43.81,71.05) 43.81,71.68 39.32,76.18 29.08,76.18 28.98,76.28 28.98,76.46 29.08,76.56 29.77,76.56 29.87,76.66 29.87,76.82 29.77,76.93 29.11,76.93 29,77.03 29,77.18 29.11,77.28 29.71,77.28 29.82,77.38 29.82,77.54 29.71,77.64 29.11,77.64 29,77.74 29,77.89 29.11,77.99 29.71,77.99 29.82,78.09 29.82,78.25 29.71,78.35 29.11,78.35 29,78.45 29,78.6 29.11,78.7 29.71,78.7 29.82,78.81 29.82,79 29.71,79.1 v12(28.8,79.1)
  IN3 w0.06: v12(43.81,71.05) 44.27,70.59 v8(44.27,69.86)
  IN3 w0.064: v12(28.8,79.1) v11(28.8,78.69) 29.03,78.69 29.23,78.89 30.86,78.89 31.19,78.56 32.58,78.56 34.26,76.89 34.26,76.15 34.51,75.9 v8(34.51,75.81)
  IN4 w0.064: v11(28.8,78.69) 28.93,78.82 29.16,78.82 29.23,78.74 29.23,78.54 28.7,78 28.7,75.06 29.21,74.55 31.26,74.55 31.51,74.79 v8(31.51,74.81)
M_0_CS2#: length 42.2
  IN2 w0.089: v12(43.35,71.58) 43.35,71.76 39.19,75.92 30.38,75.92 30.27,75.82 30.27,74.78 30.17,74.68 30.02,74.68 29.92,74.78 29.92,75.67 29.82,75.77 29.64,75.77 29.54,75.67 29.54,74.65 29.44,74.55 29.27,74.55 29.17,74.65 29.17,75.67 29.07,75.77 28.91,75.77 28.81,75.67 28.81,74.65 28.71,74.55 28.56,74.55 28.46,74.65 28.46,75.59 28.29,75.76 v12(28.29,79.1)
  IN3 w0.06: v11(43,71.78) 43.2,71.78 43.35,71.63 v12(43.35,71.58)
  IN3 w0.064: v8(34.01,76.81) 32.48,78.34 28.72,78.34 28.37,78.69 v11(28.29,78.69) v12(28.29,79.1)
  IN4 w0.06: v11(43,71.78) 43.05,71.83 44.56,71.83 v8(44.59,71.8)
  IN4 w0.064: v8(30.51,74.31) 29.12,74.31 28.5,74.93 28.5,78.08 28.57,78.16 28.57,78.77 28.52,78.82 28.42,78.82 v11(28.29,78.69)
M_0_DM0: length 21.9
  IN3 w0.06: 38.27,76.3 37.08,76.3 36.9,76.13 36.9,75.24 37.03,75.11 37.03,74.28 36.76,74.02 35.66,74.02 35.58,74.09 35.58,74.73 35.66,74.81 v8(36.01,74.81) ; v8(47.98,68.97) 47.98,69.24 47.77,69.45 47.77,69.61 47.9,69.74 47.9,69.9 47.82,69.98 47.82,71.53 47.6,71.76 47.6,71.78
  IN3 w0.064: 47.6,71.78 47.6,72.72 44.02,76.3 43.31,76.3 42.87,76.73 41.31,76.73 40.77,77.27 39.03,77.27 38.91,77.14 38.91,76.66 38.56,76.3 38.29,76.3 38.27,76.3
M_0_DM1: length 21.7
  IN4 w0.06: 38.2,75.31 37.13,75.31 37.03,75.41 37.03,75.77 v8(36.75,76.05) ; v8(47.7,70.95) 47.7,71.24 47.49,71.44 47.49,71.65 47.65,71.81 47.65,72.04 47.52,72.16 47.52,73.74 47.44,73.81 47.44,74.12
  IN4 w0.064: 47.44,74.12 47.44,74.84 44.91,77.37 44.17,77.37 44.09,77.45 44.09,77.62 44.01,77.7 41.53,77.7 41.14,78.08 39.62,78.08 39.37,77.82 39.01,77.82 38.93,77.75 38.93,77.64 39.01,77.57 39.37,77.57 39.44,77.49 39.44,77.39 39.37,77.32 38.96,77.32 38.88,77.24 38.88,77.14 38.96,77.06 39.37,77.06 39.44,76.99 39.44,76.86 39.37,76.79 38.99,76.79 38.91,76.71 38.91,76.56 38.99,76.48 39.21,76.48 39.29,76.4 39.29,76.25 39.21,76.18 39.04,76.18 38.96,76.1 38.96,75.92 38.35,75.31 38.2,75.31
  BOTTOM w0.114: U23.P4 v8(36.75,76.05)
M_0_DM2: length 15.4
  IN4 w0.06: v8(36.75,72.06) 37.94,72.06 38.2,72.32 ; v8(46,70.95) 46,71.24 46.28,71.51 46.28,71.59 46.48,71.79 46.48,72.06 45.41,73.13 45.41,73.94 45.23,74.12
  IN4 w0.064: 45.23,74.12 43.58,75.77 42.59,75.77 42.52,75.69 42.52,75.49 42.44,75.41 40.69,75.41 38.83,73.56 38.83,72.95 38.2,72.32
  BOTTOM w0.114: U23.P11 v8(36.75,72.06)
M_0_DM3: length 14
  IN3 w0.06: 38.27,71.45 38.18,71.45 37.09,72.54 36.95,72.54 36.74,72.76 36.74,72.91 36.38,73.27 36.09,73.27 35.97,73.38 35.97,73.69 36.09,73.81 v8(36.51,73.81) ; 44.59,71.78 45.72,70.65 45.72,70.39 46,70.1 v8(46,69.82)
  IN3 w0.064: 38.27,71.45 39.24,71.45 39.39,71.6 39.39,71.93 39.49,72.03 40.03,72.03 40.72,72.72 43.65,72.72 44.59,71.78
M_0_DM4: length 16.1
  IN3 w0.06: v8(35.01,70.81) 34.83,70.81 34.77,70.86 34.77,70.95 34.83,71.01 35.06,71.01 35.16,71.11 35.77,71.11 35.81,71.07 35.81,70.58 35.73,70.51 35.25,70.51 34.97,70.23 34.97,69.24 35.2,69.01 ; 42.85,68.02 42.92,68.02 43.68,67.26 43.91,67.26 44.41,66.76 45.67,66.76 v8(45.72,66.71)
  IN3 w0.064: 42.85,68.02 40.99,68.02 40.86,68.15 40.74,68.15 40.61,68.02 39.97,68.02 39.84,68.15 39.7,68.15 39.57,68.02 38.95,68.02 38.84,68.14 38.68,68.14 38.56,68.02 37.94,68.02 37.86,68.1 37.69,68.1 37.61,68.02 36.98,68.02 36.95,68.05 36.75,68.05 36.72,68.02 36.19,68.02 35.2,69.01
M_0_DM5: length 15.2
  IN4 w0.06: v8(33.51,70.81) 33.51,70.63 33.68,70.46 33.8,70.46 33.91,70.56 34.11,70.56 34.49,70.18 34.49,69.98 34.19,69.67 34.19,69.5 34.26,69.42 34.26,68.89 34.34,68.81 34.34,68.68 34.26,68.61 ; v8(44.27,66.95) 44.19,67.03 43.36,67.03 43.28,67.11 42.34,67.11 41.81,67.64 41.7,67.64 41.53,67.46 41.37,67.46 41.18,67.65 41.17,67.65
  IN4 w0.064: 41.17,67.65 40.86,67.65 40.52,68 39.29,68 39.21,67.92 39.21,67.73 39.13,67.65 39.03,67.65 38.96,67.73 38.96,67.92 38.88,68 38.76,68 38.68,67.92 38.68,67.73 38.6,67.65 34.78,67.65 34.26,68.18 34.26,68.61
M_0_DM6: length 23.9
  IN4 w0.06: 29.51,70.23 29.84,70.56 31.7,70.56 31.77,70.63 31.77,70.73 31.7,70.81 v8(31.51,70.81) ; 41.17,65.2 41.23,65.2 41.37,65.05 42.73,65.05 42.8,64.98 42.8,64.87 42.87,64.8 42.97,64.8 43.04,64.87 43.04,64.98 43.11,65.05 43.99,65.05 44.07,65.13 44.37,65.13 44.54,65.29 v8(44.87,65.29)
  IN4 w0.064: 41.17,65.2 41.04,65.2 40.9,65.33 40.66,65.33 40.48,65.15 29.77,65.15 29.35,65.57 29.35,70.07 29.51,70.23
M_0_DM7: length 22.7
  IN3 w0.06: 42.85,65.7 43.09,65.7 43.51,65.28 45.42,65.28 v8(45.44,65.29) ; v8(32.51,71.31) 32.45,71.36 32.34,71.36 32.23,71.25 32.23,71.14 32.36,71.02 32.69,71.02 32.76,70.94 32.76,70.69 32.69,70.61 32.61,70.61 32.54,70.55 32.45,70.55 32.3,70.7 32.21,70.7 32.15,70.63 32.15,70.54 32.3,70.39 32.3,70.3 31.34,69.34 31.34,69.24 31.41,69.17 31.41,69.03 31.39,69.01
  IN3 w0.064: 42.85,65.7 34.73,65.7 34.67,65.76 34.67,65.81 34.6,65.87 34.51,65.87 34.44,65.81 34.44,65.76 34.38,65.7 34.29,65.7 34.22,65.76 34.22,65.99 34.16,66.05 34.06,66.05 34,65.99 34,65.76 33.93,65.7 33.84,65.7 33.78,65.76 33.78,66.05 33.71,66.12 33.62,66.12 33.55,66.05 33.55,65.76 33.49,65.7 33.41,65.7 33.31,65.8 31.96,67.15 31.96,67.38 31.87,67.47 31.64,67.47 31.16,67.95 31.16,68.43 31.23,68.5 31.34,68.5 31.42,68.57 31.42,68.67 31.34,68.75 31.23,68.75 31.16,68.82 31.16,68.92 31.23,68.99 31.37,68.99 31.39,69.01
M_0_DQ0: length 22.5
  IN3 w0.06: 35.94,76.71 35.94,76.57 36.01,76.5 36.18,76.5 36.25,76.43 36.25,76.33 36.18,76.26 36.01,76.26 35.94,76.19 35.94,75.88 v8(36.01,75.81) ; 48.84,71.78 48.84,71.5 48.61,71.27 48.61,70.17 v8(48.55,70.1)
  IN3 w0.064: 35.94,76.71 38.03,78.81 41.17,78.81 41.25,78.73 41.25,78.56 41.32,78.49 41.42,78.49 41.5,78.56 41.5,78.73 41.58,78.81 41.68,78.81 41.75,78.73 41.75,78.56 41.83,78.49 41.93,78.49 42.01,78.56 42.01,78.73 42.08,78.81 42.19,78.81 42.26,78.73 42.26,78.56 42.34,78.49 42.44,78.49 42.52,78.56 42.52,78.73 42.59,78.81 42.69,78.81 42.77,78.73 42.77,78.56 42.85,78.49 42.95,78.49 43.02,78.56 43.02,78.73 43.1,78.81 43.27,78.81 48.84,73.23 48.84,71.78
M_0_DQ1: length 22.2
  IN3 w0.06: v8(47.42,68.97) 47.42,68.73 47.23,68.54 47.23,68.44 47.29,68.38 47.39,68.38 47.72,68.71 47.72,69.09 47.57,69.24 47.57,69.34 47.65,69.42 47.65,69.59 47.5,69.74 47.5,69.92 47.58,70 47.58,70.66 47.11,71.12 47.11,71.68 47.19,71.76 47.19,71.78 ; 38.27,75.92 37.81,75.92 37.75,75.86 v8(37.75,75.55)
  IN3 w0.064: 38.27,75.92 38.56,75.92 38.92,75.92 39,75.99 39,76.18 39.07,76.25 39.17,76.25 39.25,76.18 39.25,75.99 39.32,75.92 39.43,75.92 39.5,75.99 39.5,76.2 39.58,76.28 39.68,76.28 39.76,76.2 39.76,75.99 39.83,75.92 39.94,75.92 40.01,75.99 40.01,76.28 40.09,76.35 40.19,76.35 40.27,76.28 40.27,75.99 40.34,75.92 40.44,75.92 40.52,75.99 40.52,76.28 40.59,76.35 40.7,76.35 40.77,76.28 40.77,75.99 40.85,75.92 40.95,75.92 41.03,75.99 41.03,76.28 41.1,76.35 41.21,76.35 41.28,76.28 41.28,75.99 41.36,75.92 41.46,75.92 41.54,75.99 41.54,76.28 41.61,76.35 41.72,76.35 41.79,76.28 41.79,75.99 41.86,75.92 41.97,75.92 42.04,75.99 42.04,76.28 42.11,76.35 42.23,76.35 42.3,76.28 42.3,75.99 42.37,75.92 42.48,75.92 42.55,75.99 42.55,76.28 42.62,76.35 42.72,76.35 42.81,76.26 42.81,75.99 42.88,75.92 43.84,75.92 47.19,72.57 47.19,71.78
  BOTTOM w0.114: U23.T5 v8(37.75,75.55)
M_0_DQ2: length 22.6
  IN3 w0.06: v8(37.25,75.55) 37.4,75.55 37.51,75.44 37.51,74.8 37.17,74.46 37.17,74.36 37.27,74.26 37.38,74.26 37.79,74.68 ; 46.78,71.78 46.78,71.07 47.34,70.52 47.34,70.11 47.25,70.02 47.25,69.94 47.23,69.92 v8(47.13,69.82)
  IN3 w0.064: 37.79,74.68 38.24,74.68 38.31,74.75 38.31,74.98 38.39,75.06 38.49,75.06 38.57,74.98 38.57,74.75 38.64,74.68 38.74,74.68 38.82,74.75 38.82,74.98 38.9,75.06 39,75.06 39.07,74.98 39.07,74.75 39.15,74.68 39.25,74.68 39.33,74.75 39.33,74.98 39.4,75.06 39.51,75.06 39.58,74.98 39.58,74.75 39.66,74.68 39.76,74.68 39.84,74.75 39.84,74.98 39.91,75.06 40.01,75.06 40.09,74.98 40.09,74.75 40.17,74.68 40.27,74.68 40.34,74.75 40.34,74.98 40.42,75.06 40.52,75.06 40.6,74.98 40.6,74.75 40.67,74.68 40.78,74.68 40.85,74.75 40.85,74.98 40.93,75.06 41.03,75.06 41.11,74.98 41.11,74.75 41.18,74.68 41.28,74.68 41.36,74.75 41.36,74.98 41.44,75.06 41.54,75.06 41.61,74.98 41.61,74.75 41.69,74.68 41.79,74.68 41.87,74.75 41.87,74.98 41.94,75.06 42.05,75.06 42.12,74.98 42.12,74.75 42.2,74.68 42.3,74.68 42.38,74.75 42.38,74.98 42.45,75.06 42.55,75.06 42.63,74.98 42.63,74.75 42.71,74.68 42.81,74.68 42.88,74.75 42.88,74.98 42.96,75.06 43.06,75.06 43.14,74.98 43.14,74.75 43.21,74.68 43.32,74.68 43.39,74.75 43.39,74.98 43.47,75.06 43.57,75.06 43.65,74.98 43.65,74.75 43.72,74.68 43.82,74.68 43.9,74.75 43.9,74.98 43.98,75.06 44.08,75.06 44.15,74.98 44.15,74.75 44.23,74.68 44.52,74.68 46.78,72.42 46.78,71.78
  BOTTOM w0.114: v8(37.25,75.55) 37.01,75.31 U23.R5
M_0_DQ3: length 21.7
  IN3 w0.06: 48.64,71.78 48.64,71.53 48.49,71.38 48.49,70.33 48.35,70.19 48.35,70.02 48.46,69.9 48.46,69.74 48.33,69.61 48.33,69.32 v8(48.26,69.26) ; v8(36.27,75.54) 36.37,75.64 36.37,76.85 36.66,77.14
  IN3 w0.064: 36.66,77.14 38.14,78.61 40.35,78.61 40.43,78.54 40.43,78.37 40.5,78.3 40.61,78.3 40.68,78.37 40.68,78.54 40.75,78.61 40.86,78.61 40.93,78.54 40.93,78.37 41.01,78.3 43.49,78.3 43.55,78.23 43.56,78.23 48.64,73.15 48.64,71.78
  BOTTOM w0.114: U23.P5 36.5,75.31 v8(36.27,75.54)
M_0_DQ4: length 22.1
  IN3 w0.06: 36.22,77.27 35.8,76.85 35.8,75.51 v8(36.01,75.31) ; v8(48.55,69.54) 48.79,69.78 48.79,71.12 49.04,71.38 49.04,71.78
  IN3 w0.064: 49.04,71.78 49.04,73.31 43.35,79 37.94,79 36.22,77.27
M_0_DQ5: length 23.1
  IN3 w0.06: 46.99,71.78 46.99,71.05 47.46,70.57 47.46,70.06 47.37,69.97 47.37,69.58 v8(47.42,69.54) ; 38.27,75.72 38.25,75.74 38.15,75.74 38.07,75.67 38.07,75.33 38,75.25 37.96,75.25 v8(37.75,75.05)
  IN3 w0.064: 38.27,75.72 38.33,75.67 38.33,75.34 38.4,75.26 38.52,75.26 38.59,75.33 38.59,75.64 38.66,75.72 38.77,75.72 38.84,75.64 38.84,75.32 38.92,75.25 39.02,75.25 39.1,75.32 39.1,75.64 39.17,75.72 39.28,75.72 39.35,75.64 39.35,75.32 39.42,75.25 39.53,75.25 39.6,75.32 39.6,75.64 39.68,75.72 39.78,75.72 39.86,75.64 39.86,75.32 39.93,75.25 40.04,75.25 40.11,75.32 40.11,75.64 40.19,75.72 40.29,75.72 40.37,75.64 40.37,75.32 40.44,75.25 40.55,75.25 40.62,75.32 40.62,75.64 40.69,75.72 40.8,75.72 40.87,75.64 40.87,75.32 40.95,75.25 41.05,75.25 41.13,75.32 41.13,75.64 41.2,75.72 41.31,75.72 41.38,75.64 41.38,75.32 41.46,75.25 41.56,75.25 41.64,75.32 41.64,75.64 41.71,75.72 41.82,75.72 41.89,75.64 41.89,75.32 41.96,75.25 42.07,75.25 42.14,75.32 42.14,75.64 42.22,75.72 42.32,75.72 42.4,75.64 42.4,75.32 42.47,75.25 42.58,75.25 42.65,75.32 42.65,75.64 42.73,75.72 42.83,75.72 42.91,75.64 42.91,75.32 42.98,75.25 43.09,75.25 43.16,75.32 43.16,75.64 43.23,75.72 43.34,75.72 43.41,75.64 43.41,75.32 43.49,75.25 43.59,75.25 43.67,75.32 43.67,75.57 43.74,75.64 43.85,75.64 43.92,75.57 43.92,75.32 44,75.25 44.23,75.25 46.99,72.49 46.99,71.78
  BOTTOM w0.114: v8(37.75,75.05) 37.52,74.81 U23.T6
M_0_DQ6: length 21.9
  IN3 w0.06: 38.27,76.11 38.16,76.11 38.1,76.05 37.92,76.05 37.79,76.18 37.64,76.18 37.59,76.13 37.59,75.82 37.51,75.74 37.44,75.74 37.36,75.82 37.36,76.07 37.28,76.15 37.11,76.15 37.03,76.07 37.03,75.97 37.16,75.85 37.16,75.77 37.03,75.64 37.03,75.41 37.11,75.34 37.28,75.34 37.36,75.26 37.36,75.16 v8(37.25,75.05) ; 47.39,71.78 47.39,71.76 47.24,71.6 47.24,71.49 47.31,71.43 47.62,71.43 47.7,71.35 47.7,71.27 47.62,71.2 47.44,71.2 47.37,71.12 47.37,71.04 47.44,70.97 47.62,70.97 47.7,70.89 v8(47.7,69.82)
  IN3 w0.064: 38.27,76.11 38.71,76.11 38.78,76.19 38.78,76.25 39.11,76.58 39.11,77 39.18,77.07 39.28,77.07 39.36,77 39.36,76.56 39.44,76.48 39.54,76.48 39.61,76.56 39.61,77 39.69,77.07 39.79,77.07 39.87,77 39.87,76.63 39.94,76.56 40.05,76.56 40.12,76.63 40.12,77 40.2,77.07 40.3,77.07 40.38,77 40.38,76.63 40.45,76.56 40.56,76.56 40.64,76.63 40.64,76.86 40.71,76.94 40.81,76.94 40.89,76.86 40.89,76.63 40.98,76.54 42.79,76.54 43,76.34 43,76.18 43.07,76.11 43.93,76.11 47.39,72.65 47.39,71.78
  BOTTOM w0.114: U23.R6 v8(37.25,75.05)
M_0_DQ7: length 22.2
  IN3 w0.06: 48.43,71.71 48.43,71.6 48.26,71.43 v8(48.26,70.39) ; v8(36.51,74.81) 36.51,74.86 36.43,74.93 36.19,74.93 36.12,75.01 36.12,75.11 36.19,75.19 36.43,75.19 36.51,75.26 36.51,76.7
  IN3 w0.064: 36.51,76.7 36.68,76.86 36.78,76.86 36.85,76.79 36.96,76.79 37.03,76.87 37.03,76.97 36.96,77.04 36.96,77.15 37.54,77.73 37.77,77.73 37.87,77.83 37.87,78.06 37.92,78.11 38.31,78.11 38.38,78.18 38.38,78.34 38.46,78.41 38.56,78.41 38.64,78.34 38.64,78.16 38.71,78.08 38.82,78.08 38.89,78.16 38.89,78.34 38.97,78.41 39.07,78.41 39.15,78.34 39.15,78.16 39.22,78.08 39.32,78.08 39.4,78.16 39.4,78.34 39.47,78.41 39.58,78.41 39.65,78.34 39.65,78.16 39.73,78.08 39.83,78.08 39.91,78.16 39.91,78.34 39.98,78.41 40.09,78.41 40.16,78.34 40.16,78.18 40.24,78.11 43.41,78.11 48.43,73.08 48.43,71.71
M_0_DQ8: length 22.1
  IN4 w0.06: 37.03,77.75 36.95,77.67 36.78,77.67 36.7,77.6 36.7,77.47 36.8,77.37 36.8,77.29 36.67,77.17 36.67,77.09 36.8,76.96 36.8,76.56 36.73,76.48 36.58,76.48 36.51,76.56 v8(36.51,76.81) ; v8(48.55,71.88) 48.76,72.09 48.76,73.13 48.84,73.2 49.12,73.2 49.2,73.28 49.2,73.64 49.27,73.71 49.37,73.71 49.43,73.76 49.43,74.12
  IN4 w0.064: 49.43,74.12 49.43,74.79 44.47,79.74 44.13,79.74 44,79.87 43.87,79.87 43.75,79.74 43.62,79.74 43.49,79.87 43.37,79.87 43.24,79.74 43.11,79.74 42.98,79.87 42.86,79.87 42.73,79.74 42.6,79.74 42.48,79.87 42.35,79.87 42.22,79.74 42.1,79.74 41.97,79.87 41.84,79.87 41.71,79.74 41.59,79.74 41.46,79.87 41.33,79.87 41.21,79.74 41.08,79.74 40.95,79.87 40.83,79.87 40.7,79.74 40.57,79.74 40.44,79.87 40.32,79.87 40.19,79.74 40.06,79.74 39.94,79.87 39.81,79.87 39.68,79.74 39.56,79.74 39.43,79.87 39.3,79.87 39.17,79.74 38.85,79.74 37.03,77.93 37.03,77.75
M_0_DQ9: length 21.8
  IN4 w0.06: v8(47.17,71.56) 47.1,71.63 47.1,72.05 47.14,72.09 47.14,73.41 46.83,73.71 46.83,73.94 46.66,74.12 ; v8(36.01,76.31) 36.04,76.27 36.04,76.07 36.47,75.64 36.47,75.16 37.11,74.53 38.2,74.53
  IN4 w0.064: 38.2,74.53 38.4,74.53 40.64,76.76 43.99,76.76 44.48,76.27 44.59,76.27 44.85,76.53 44.94,76.53 45.03,76.44 45.03,76.35 44.76,76.08 44.76,75.97 44.83,75.9 44.94,75.9 45.2,76.16 45.31,76.16 45.38,76.09 45.38,75.98 45.12,75.72 45.12,75.61 45.19,75.54 45.3,75.54 45.56,75.8 45.67,75.8 45.74,75.73 45.74,75.62 45.48,75.36 45.48,75.25 45.55,75.18 45.66,75.18 45.92,75.44 46.03,75.44 46.1,75.37 46.1,75.26 45.84,75 45.84,74.89 45.91,74.82 46.02,74.82 46.28,75.08 46.39,75.08 46.46,75.01 46.46,74.9 46.2,74.64 46.2,74.53 46.27,74.46 46.38,74.46 46.64,74.72 46.75,74.72 46.83,74.64 46.83,74.53 46.61,74.3 46.61,74.17 46.66,74.12
M_0_DQ10: length 21.3
  IN4 w0.06: v8(48.26,71.52) 48.26,71.7 48.21,71.76 48.21,71.99 48.28,72.07 48.41,72.19 48.41,73.97 48.54,74.09 48.71,74.09 48.79,74.02 48.97,74.02 49.04,74.09 49.04,74.12
  IN4 w0.064: 49.04,74.12 49.04,74.64 45.22,78.46 44.88,78.46 44.8,78.54 44.8,78.88 44.32,79.36 39.21,79.36 39.14,79.29 39.14,79.17 39.06,79.1 38.76,79.1 37.87,78.21 37.87,77.93 37.79,77.85 37.51,77.85 37.44,77.78 37.44,77.65 37.51,77.57 37.79,77.57 37.87,77.5 37.87,77.4 37.72,77.24 37.72,77.09 37.87,76.94 37.87,76.61 37.79,76.53 37.28,76.53 37.21,76.61 37.21,76.73 37.28,76.81 v8(37.51,76.81)
M_0_DQ11: length 22.1
  IN4 w0.06: 38.2,75.01 38.07,75.01 37.89,74.83 37.16,74.83 36.88,75.11 36.88,75.62 36.52,75.97 36.52,76.23 36.6,76.31 v8(37.01,76.31) ; 47.24,74.12 47.24,73.77 47.38,73.64 47.38,71.91 v8(47.42,71.88)
  IN4 w0.064: 47.24,74.12 47.24,74.77 44.84,77.17 43.96,77.17 43.89,77.24 43.89,77.42 43.81,77.5 41.28,77.5 41.21,77.42 41.21,77.24 41.13,77.17 41.03,77.17 40.95,77.24 40.95,77.5 40.88,77.57 40.77,77.57 40.7,77.5 40.7,77.24 40.62,77.17 40.52,77.17 40.44,77.24 40.44,77.8 40.37,77.88 40.26,77.88 40.19,77.8 40.19,76.86 40.11,76.79 40.01,76.79 39.94,76.86 39.94,77.8 39.86,77.88 39.75,77.88 39.67,77.8 39.67,76.34 38.34,75.01 38.2,75.01
M_0_DQ12: length 21.1
  IN4 w0.06: v8(36.27,76.55) 36.27,76.02 36.73,75.57 36.73,75.08 37.13,74.68 38,74.68 38.1,74.78 38.2,74.78 ; 47.04,74.12 47.04,73.76 47.26,73.53 47.26,72.04 47.22,72 47.22,71.79 47.37,71.64 47.37,71.47 47.22,71.32 47.22,71.15 47.42,70.95 v8(47.42,70.67)
  IN4 w0.064: 38.2,74.78 38.38,74.78 40.56,76.96 41.33,76.96 41.41,77.04 41.41,77.22 41.48,77.29 41.59,77.29 41.66,77.22 41.66,77.04 41.74,76.96 41.84,76.96 41.92,77.04 41.92,77.22 41.99,77.29 42.1,77.29 42.17,77.22 42.17,77.04 42.24,76.96 42.35,76.96 42.42,77.04 42.42,77.22 42.5,77.29 42.6,77.29 42.68,77.22 42.68,77.04 42.75,76.96 42.86,76.96 42.93,77.04 42.93,77.22 43.01,77.29 43.11,77.29 43.19,77.22 43.19,77.04 43.26,76.96 43.37,76.96 43.44,77.04 43.44,77.22 43.51,77.29 43.62,77.29 43.69,77.22 43.69,77.04 43.77,76.96 44.78,76.96 47.04,74.7 47.04,74.12
  BOTTOM w0.114: U23.P3 36.51,76.31 v8(36.27,76.55)
M_0_DQ13: length 21.3
  IN4 w0.06: v8(47.98,70.67) 47.98,70.95 48.18,71.15 48.18,71.32 48.06,71.44 48.06,71.6 48.06,72.02 48.24,72.19 48.24,74 48.31,74.07 48.31,74.12 ; 38.07,77.19 38.07,76.43 37.94,76.3 37.51,76.3 v8(37.51,76.31)
  IN4 w0.064: 48.31,74.12 48.31,75.1 45.15,78.26 44.68,78.26 44.6,78.34 44.6,78.81 44.24,79.17 41.43,79.17 41.36,79.1 41.36,78.96 41.28,78.89 41.18,78.89 41.1,78.96 41.1,79.1 41.03,79.17 40.92,79.17 40.85,79.1 40.85,78.96 40.77,78.89 40.67,78.89 40.59,78.96 40.59,79.1 40.52,79.17 40.41,79.17 40.34,79.1 40.34,78.96 40.26,78.89 40.16,78.89 40.09,78.96 40.09,79.1 40.01,79.17 39.91,79.17 39.83,79.1 39.83,78.96 39.76,78.89 39.65,78.89 39.58,78.96 39.58,79.1 39.5,79.17 39.39,79.17 39.32,79.1 39.32,78.94 39.27,78.89 38.82,78.89 38.07,78.14 38.07,77.19
M_0_DQ14: length 21.9
  IN4 w0.06: 49.23,74.12 49.23,73.94 49.16,73.86 48.66,73.86 48.59,73.79 48.59,73.69 48.66,73.61 48.97,73.61 49.04,73.54 49.04,73.44 48.97,73.37 48.68,73.37 48.6,73.3 48.6,72.22 48.35,71.96 48.35,71.79 48.46,71.68 48.46,71.44 48.31,71.28 48.31,71 v8(48.26,70.95) ; 37.23,77.75 37.23,77.57 37.16,77.5 37.05,77.5 36.98,77.42 36.98,77.32 37.05,77.24 37.29,77.24 37.36,77.17 37.36,77.06 37.29,76.99 37.08,76.99 37.01,76.91 v8(37.01,76.81)
  IN4 w0.064: 37.23,77.75 37.23,77.85 38.68,79.3 38.86,79.3 38.93,79.38 38.93,79.45 39.04,79.55 44.4,79.55 44.99,78.96 44.99,78.75 45.08,78.67 45.28,78.67 49.23,74.72 49.23,74.12
M_0_DQ15: length 22.1
  IN4 w0.06: 49.62,74.12 49.62,73.5 48.92,72.8 48.92,71.96 48.59,71.64 48.59,71.47 48.75,71.32 48.75,71.15 48.63,71.04 48.63,71.04 48.55,70.96 v8(48.55,70.67) ; 36.57,77.75 36.01,77.19 v8(36.01,76.81)
  IN4 w0.064: 49.62,74.12 49.62,74.87 44.43,80.06 38.88,80.06 36.57,77.75
M_0_DQ16: length 16.7
  IN4 w0.06: v8(46.57,70.95) 46.65,71.04 46.65,71.39 46.73,71.47 46.73,72.3 46.33,72.7 46.33,73.59 45.79,74.12 ; v8(36.51,71.31) 36.29,71.52 36.29,71.96 36.37,72.04 36.37,72.16 36.85,72.65 37.51,72.65 37.64,72.77 37.77,72.77 38.05,73.05 38.05,73.2 38.2,73.36
  IN4 w0.064: 38.2,73.36 38.43,73.59 38.43,73.71 40.87,76.15 43.76,76.15 45.79,74.12
M_0_DQ17: length 16.9
  IN4 w0.06: 46.34,74.12 46.71,73.75 46.71,73.61 46.97,73.35 46.97,71.47 47.05,71.39 47.05,71.04 v8(47.13,70.95) ; v8(36.01,72.31) 36.27,72.57 36.27,72.87 36.47,73.08 36.98,73.08 37.21,73.31 37.36,73.31 37.51,73.46 37.51,73.74 37.82,74.04 38.2,74.04
  IN4 w0.064: 46.34,74.12 43.9,76.56 40.71,76.56 38.2,74.04
M_0_DQ18: length 16.4
  IN4 w0.06: 38.2,73.66 37.84,73.31 37.66,73.31 37.54,73.18 37.54,72.92 37.41,72.8 36.8,72.8 36.19,72.19 36.19,72.06 36.01,71.88 v8(36.01,71.81) ; 46.07,74.12 46.48,73.71 46.48,72.75 46.85,72.38 v8(46.85,71.24)
  IN4 w0.064: 46.07,74.12 43.84,76.35 40.79,76.35 38.22,73.79 38.22,73.69 38.2,73.66
M_0_DQ19: length 15.5
  IN4 w0.06: v8(37.51,70.81) 37.63,70.68 38.2,70.68 ; v8(45.44,71.52) 45.52,71.6 45.52,72.03 44.35,73.21 44.19,73.21
  IN4 w0.064: 44.19,73.21 43.85,73.21 43.78,73.13 43.78,73 43.7,72.92 43.6,72.92 43.52,73 43.52,73.18 43.45,73.26 43.33,73.26 43.25,73.18 43.25,73.08 43.18,73 43.08,73 43,73.08 43,73.18 42.92,73.26 42.82,73.26 42.74,73.18 42.74,72.62 42.67,72.54 42.55,72.54 42.48,72.62 42.48,72.96 42.4,73.04 42.3,73.04 42.22,72.96 42.22,72.62 42.15,72.54 42.04,72.54 41.97,72.62 41.97,72.96 41.89,73.04 41.79,73.04 41.71,72.96 41.71,72.62 41.64,72.54 41.54,72.54 41.46,72.62 41.46,73.26 41.39,73.33 41.28,73.33 41.21,73.26 41.21,72.62 41.13,72.54 40.56,72.54 40.48,72.47 40.48,72.01 40.41,71.93 40.28,71.93 40.2,72.01 40.2,72.34 40.13,72.42 40,72.42 39.93,72.34 39.93,72.01 39.85,71.93 39.51,71.93 39.37,71.79 39.37,71.55 38.5,70.68 38.2,70.68
M_0_DQ20: length 16.4
  IN4 w0.06: v8(36.51,71.81) 36.51,72.12 36.9,72.52 37.28,72.52 37.53,72.28 37.88,72.28 38.2,72.59 ; 45.51,74.12 46.17,73.46 46.17,72.62 46.6,72.19 46.6,71.63 v8(46.53,71.56)
  IN4 w0.064: 38.2,72.59 38.63,73.03 38.63,73.64 40.61,75.62 41.22,75.62 41.29,75.69 41.29,75.88 41.37,75.96 41.47,75.96 41.55,75.88 41.55,75.69 41.62,75.62 41.73,75.62 41.8,75.69 41.8,75.88 41.88,75.96 41.98,75.96 42.06,75.88 42.06,75.69 42.13,75.62 42.23,75.62 42.31,75.69 42.31,75.88 42.39,75.96 43.67,75.96 45.51,74.12
M_0_DQ21: length 14.5
  IN4 w0.06: 38.2,70.46 38.17,70.46 38.1,70.54 37.08,70.54 37.01,70.61 v8(37.01,70.81) ; 43.33,72.77 43.94,72.77 44.19,72.52 44.87,72.52 45.36,72.03 45.36,71.77 45.24,71.65 45.24,71.44 45.35,71.32 45.35,71.32 45.35,71.15 45.21,71.01 45.21,70.8 45.34,70.67 v8(45.72,70.67)
  IN4 w0.064: 43.33,72.77 43.18,72.77 42.74,72.34 41.7,72.34 41.63,72.26 41.63,72.11 41.55,72.04 41.42,72.04 41.35,72.11 41.35,72.26 41.27,72.34 40.76,72.34 40.69,72.26 40.69,71.32 40.63,71.26 40.49,71.26 40.41,71.34 40.41,71.66 40.34,71.73 40.23,71.73 40.16,71.66 40.16,71.34 40.08,71.26 39.98,71.26 39.9,71.34 39.9,71.66 39.83,71.73 39.72,71.73 39.65,71.66 39.65,71.34 39.57,71.26 39.35,71.26 39.21,71.12 39.21,70.79 39.14,70.72 38.81,70.72 38.55,70.46 38.2,70.46
M_0_DQ22: length 16.5
  IN4 w0.06: 38.2,70.92 37.77,70.92 37.64,71.05 36.83,71.05 36.75,71.12 36.75,71.48 36.83,71.55 36.93,71.55 37.01,71.48 v8(37.01,71.31) ; v8(46.28,70.67) 46,70.67 45.5,71.17 45.5,71.3 45.68,71.48 45.68,71.68 45.64,71.72 45.64,72.08 44.47,73.25 44.47,73.36 44.41,73.42
  IN4 w0.064: 44.41,73.42 44.37,73.46 42.62,73.46 42.54,73.38 42.54,73.31 42.47,73.23 42.34,73.23 42.26,73.31 42.26,73.43 42.19,73.51 42.08,73.51 42.01,73.43 42.01,73.3 41.93,73.23 41.83,73.23 41.75,73.3 41.75,73.45 41.68,73.52 41.07,73.52 40.99,73.45 40.99,72.82 40.92,72.75 40.81,72.75 40.74,72.82 40.74,73.56 40.66,73.64 40.54,73.64 40.46,73.56 40.46,72.72 40.38,72.65 39.95,72.65 39.72,72.41 39.72,72.26 39.62,72.16 39.47,72.16 39.16,71.85 39.16,71.61 38.47,70.92 38.2,70.92
M_0_DQ23: length 15.4
  IN4 w0.06: 44.55,73.56 44.6,73.51 44.6,73.29 45.8,72.1 45.8,71.32 v8(45.72,71.24) ; 38.12,71.07 37.84,71.07 37.61,71.31 v8(37.51,71.31)
  IN4 w0.064: 38.12,71.07 38.22,71.17 38.45,71.17 38.96,71.68 38.96,71.92 39.72,72.68 39.72,73.28 39.8,73.36 39.9,73.36 39.98,73.28 39.98,72.92 40.05,72.85 40.16,72.85 40.23,72.92 40.23,73.76 40.31,73.84 40.81,73.84 40.94,73.71 41.45,73.71 41.53,73.79 41.53,73.89 41.6,73.97 41.71,73.97 41.78,73.89 41.78,73.79 41.86,73.71 41.95,73.71 42.03,73.79 42.03,73.9 42.11,73.97 42.21,73.97 42.28,73.9 42.28,73.71 42.36,73.64 42.46,73.64 42.54,73.71 42.54,73.89 42.61,73.97 42.72,73.97 42.79,73.89 42.79,73.74 42.87,73.66 42.97,73.66 43.05,73.74 43.05,73.9 43.12,73.97 43.22,73.97 43.3,73.9 43.3,73.74 43.37,73.66 43.48,73.66 43.55,73.74 43.55,73.92 43.63,73.99 43.73,73.99 43.81,73.92 43.81,73.74 43.88,73.66 43.99,73.66 44.06,73.74 44.06,73.89 44.14,73.97 44.24,73.97 44.32,73.89 44.32,73.79 44.39,73.71 44.4,73.71 44.55,73.56
M_0_DQ24: length 13.5
  IN3 w0.06: v8(37.01,72.31) 37.01,72.17 36.78,71.94 36.78,71.85 36.85,71.79 36.93,71.79 37.2,72.05 37.29,72.05 37.36,71.99 37.36,71.89 37.02,71.55 37.02,71.46 37.08,71.4 37.17,71.4 37.5,71.72 37.59,71.72 37.65,71.66 37.65,71.57 37.46,71.37 37.46,71.28 37.52,71.22 37.61,71.22 37.81,71.41 37.9,71.41 38.05,71.26 38.27,71.26 ; 44.32,71.78 45.56,70.54 45.56,70.36 45.72,70.21 v8(45.72,70.1)
  IN3 w0.064: 44.32,71.78 43.57,72.53 40.8,72.53 40.11,71.84 39.66,71.84 39.58,71.77 39.58,71.53 39.32,71.26 38.27,71.26
M_0_DQ25: length 14.4
  IN3 w0.06: 46.17,71.78 46.35,71.6 46.35,70.94 46.77,70.51 46.77,70.18 v8(46.85,70.1) ; 38.27,73.38 37.89,73.38 37.75,73.24 v8(37.75,73.06)
  IN3 w0.064: 38.27,73.38 38.48,73.38 38.73,73.64 38.73,74.02 38.81,74.09 38.95,74.09 39.01,74.03 39.01,74.01 39.08,73.94 39.17,73.94 39.23,74.01 39.23,74.03 39.3,74.09 39.39,74.09 39.46,74.03 39.46,74.01 39.52,73.94 39.61,73.94 39.68,74.01 39.68,74.03 39.74,74.09 39.84,74.09 39.9,74.03 39.9,74.01 39.97,73.94 40.06,73.94 40.12,74.01 40.12,74.03 40.19,74.09 40.28,74.09 40.35,74.03 40.35,74.01 40.41,73.94 40.5,73.94 40.57,74.01 40.57,74.03 40.63,74.09 40.73,74.09 40.79,74.03 40.79,74.01 40.86,73.94 40.95,73.94 41.01,74.01 41.01,74.03 41.08,74.09 41.17,74.09 41.24,74.03 41.24,74.01 41.3,73.94 41.39,73.94 41.46,74.01 41.46,74.03 41.52,74.09 41.61,74.09 41.68,74.03 41.68,74.01 41.74,73.94 41.84,73.94 41.9,74.01 41.9,74.03 41.97,74.09 42.06,74.09 42.12,74.03 42.12,74.01 42.19,73.94 42.28,73.94 42.35,74.01 42.35,74.03 42.41,74.09 42.5,74.09 42.57,74.03 42.57,74.01 42.63,73.94 42.73,73.94 42.79,74.01 42.79,74.03 42.86,74.09 42.95,74.09 43.01,74.03 43.01,74.01 43.08,73.94 43.17,73.94 43.24,74.01 43.24,74.03 43.3,74.09 43.39,74.09 43.46,74.03 43.46,74.01 43.52,73.94 43.61,73.94 43.68,74.01 43.68,74.03 43.74,74.09 43.84,74.09 43.9,74.03 43.9,74.01 43.97,73.94 44.19,73.94 44.75,73.38 44.94,73.38 46.17,72.15 46.17,71.78
  BOTTOM w0.114: U23.T10 v8(37.75,73.06)
M_0_DQ26: length 13.8
  IN3 w0.06: 38.27,74.47 38,74.47 37.56,74.04 37.3,74.04 37.23,73.98 37.23,73.88 37.3,73.81 37.46,73.81 37.54,73.74 37.54,73.62 37.46,73.55 v8(37.25,73.55) ; 46.59,71.78 46.59,71.04 47.05,70.58 v8(47.13,70.39)
  IN3 w0.064: 38.27,74.47 44.42,74.47 46.59,72.3 46.59,71.78
  BOTTOM w0.114: U23.R9 v8(37.25,73.55)
M_0_DQ27: length 13.7
  IN3 w0.06: 38.27,74.28 38.08,74.28 37.75,73.95 v8(37.75,73.55) ; 46.38,71.78 46.47,71.69 46.47,70.99 46.9,70.55 46.9,70.33 47.05,70.19 47.05,70.02 47.04,70.01 46.93,69.9 46.93,69.46 v8(47.13,69.26)
  IN3 w0.064: 46.38,71.78 46.38,72.21 44.31,74.28 38.27,74.28
  BOTTOM w0.114: U23.T9 v8(37.75,73.55)
M_0_DQ28: length 13.4
  IN3 w0.06: 45.74,71.78 45.74,71.71 46.11,71.34 46.11,70.73 46.36,70.48 46.36,70.31 46.73,69.94 46.73,69.83 46.68,69.78 46.61,69.78 v8(46.57,69.82) ; 38.27,72.89 38.22,72.94 38.12,72.94 38.05,72.87 38.05,72.57 37.97,72.49 37.79,72.49 v8(37.75,72.53)
  IN3 w0.064: 45.74,71.78 45.74,71.97 45.65,72.06 45.46,72.06 45.36,72.16 45.36,72.34 45.26,72.44 45.08,72.44 43.96,73.56 39.77,73.56 39.7,73.48 39.7,73.35 39.62,73.28 39.52,73.28 39.44,73.35 39.44,73.49 39.37,73.56 39.27,73.56 39.2,73.49 39.2,73.35 39.14,73.29 38.93,73.29 38.55,72.9 38.55,72.71 38.47,72.64 38.37,72.64 38.3,72.71 38.3,72.87 38.27,72.89
  BOTTOM w0.114: U23.T11 v8(37.75,72.53)
M_0_DQ29: length 13.1
  IN3 w0.06: 44.04,71.78 45.39,70.44 45.39,70.36 45.51,70.23 45.51,70.03 45.72,69.82 v8(45.72,69.54) ; 38.27,71.07 37.13,71.07 36.7,71.5 36.7,71.69 36.5,71.89 36.5,72.19 36.55,72.24 36.67,72.24 36.75,72.32 36.75,72.44 36.67,72.52 36.58,72.52 36.51,72.59 v8(36.51,72.81)
  IN3 w0.064: 44.04,71.78 43.48,72.34 40.87,72.34 40.19,71.65 39.9,71.65 39.77,71.53 39.77,71.24 39.6,71.07 38.27,71.07
M_0_DQ30: length 13.1
  IN3 w0.06: v8(46.57,70.39) 46.57,70.55 46.23,70.89 46.23,71.44 45.97,71.71 45.97,71.78 ; v8(37.25,73.04) 37.25,73.04 37.25,73.28 37.32,73.36 37.46,73.36 37.54,73.28 37.54,72.85 37.61,72.77 37.82,72.77 37.89,72.85 37.89,72.9 37.97,72.98 37.97,73.13 38.03,73.19 38.27,73.19
  IN3 w0.064: 45.97,71.78 45.97,72.08 45.41,72.65 45.16,72.65 45.06,72.74 45.06,73 44.97,73.08 44.71,73.08 44.04,73.75 39.13,73.75 38.57,73.19 38.27,73.19
  BOTTOM w0.114: U23.R10 37.01,72.81 v8(37.25,73.04)
M_0_DQ31: length 13.9
  IN3 w0.06: 38.27,70.88 37.04,70.88 36.5,71.43 36.5,71.59 36.23,71.86 35.9,71.86 35.84,71.92 35.84,72.01 35.9,72.08 36.2,72.08 36.27,72.14 36.27,72.23 36.2,72.3 35.9,72.3 35.84,72.36 35.84,72.45 35.9,72.51 36.19,72.51 36.27,72.59 36.27,72.73 36.19,72.81 v8(36.01,72.81) ; v8(45.44,69.82) 45.39,69.87 45.39,70.13 43.74,71.78
  IN3 w0.064: 43.74,71.78 43.41,72.11 40.92,72.11 39.68,70.88 38.27,70.88
M_0_DQ32: length 14.4
  IN3 w0.06: v8(46.28,67.84) 46.28,67.77 46.22,67.72 45.95,67.72 45.83,67.66 45.72,67.63 44.92,67.63 44.56,67.98 44.56,68.72 44.48,68.8 44.23,68.8 44.15,68.88 44.15,69.19 44.07,69.27 42.26,69.27 41.86,69.67 41.86,70.11 41.78,70.18 41.56,70.18 ; 36.87,70.46 36.82,70.41 36.61,70.41 v8(36.51,70.31)
  IN3 w0.064: 36.87,70.46 36.87,70.52 36.94,70.59 37.03,70.59 37.1,70.52 37.1,70.48 37.16,70.41 37.25,70.41 37.32,70.48 37.32,70.52 37.38,70.59 37.48,70.59 37.54,70.52 37.54,70.48 37.61,70.41 37.7,70.41 37.76,70.48 37.76,70.52 37.83,70.59 37.92,70.59 37.99,70.52 37.99,70.48 38.05,70.41 38.14,70.41 38.21,70.48 38.21,70.52 38.27,70.59 38.37,70.59 38.43,70.52 38.43,70.48 38.5,70.41 38.59,70.41 38.65,70.48 38.65,70.52 38.72,70.59 38.81,70.59 38.87,70.52 38.87,70.48 38.94,70.41 39.03,70.41 39.1,70.48 39.1,70.52 39.16,70.59 39.25,70.59 39.32,70.52 39.32,70.41 39.38,70.34 39.48,70.34 39.54,70.41 39.54,70.52 39.61,70.59 39.7,70.59 39.76,70.52 39.76,70.21 39.83,70.14 39.92,70.14 39.99,70.21 39.99,70.52 40.05,70.59 40.14,70.59 40.21,70.52 40.21,70.25 40.27,70.18 41.56,70.18
M_0_DQ33: length 14.5
  IN3 w0.06: v8(36.51,69.81) 36.51,69.81 36.51,70 36.58,70.08 36.75,70.08 36.89,70.22 38.27,70.22 ; 41.56,69.74 42.16,69.14 43.2,69.14 43.38,68.96 43.48,68.96 43.54,69.03 43.64,69.03 43.71,68.96 43.71,68.86 43.65,68.8 43.65,68.7 43.72,68.63 43.82,68.63 43.92,68.73 44.02,68.73 44.09,68.66 44.09,68.56 43.99,68.46 43.99,68.36 44.06,68.29 44.16,68.29 44.21,68.34 44.31,68.34 44.38,68.27 44.38,68.17 44.33,68.12 44.33,68.02 44.83,67.51 45.75,67.51 45.87,67.55 46.03,67.59 46.55,67.59 46.66,67.49 47.48,67.49 47.55,67.56 47.55,67.64 47.47,67.72 46.97,67.72 v8(46.85,67.84)
  IN3 w0.064: 41.56,69.74 41.35,69.95 39.39,69.95 39.32,70.03 39.32,70.14 39.24,70.22 38.27,70.22
M_0_DQ34: length 15.8
  IN3 w0.06: v8(46.57,66.43) 46.57,66.36 46.5,66.3 46.41,66.3 46.08,66.63 45.92,66.63 45.77,66.47 45.67,66.47 45.52,66.63 44.38,66.63 44.3,66.7 44.17,66.7 44.09,66.78 44.09,66.91 43.92,67.08 43.68,67.08 42.93,67.83 42.85,67.83 ; 34.93,69.01 34.85,69.1 34.85,70.33 34.9,70.38 34.9,70.56 34.94,70.61 35.17,70.61 35.23,70.66 35.23,70.89 35.32,70.99 35.51,70.99 35.56,70.93 35.56,70.86 v8(35.51,70.81)
  IN3 w0.064: 42.85,67.83 36.11,67.83 34.93,69.01
M_0_DQ35: length 14.8
  IN3 w0.06: 41.56,69.13 41.83,68.86 43.08,68.86 44.67,67.27 45.81,67.27 45.94,67.32 46.24,67.32 v8(46.28,67.27) ; 38.27,69.52 38.15,69.39 37.39,69.39 37.29,69.49 37.29,69.71 37.23,69.78 37.13,69.78 37.06,69.71 37.06,69.26 36.99,69.19 36.9,69.19 36.83,69.26 36.83,69.42 36.75,69.5 36.67,69.5 36.6,69.42 36.6,69.27 36.52,69.19 36.24,69.19 36.03,69.41 36.03,69.77 36.1,69.84 36.25,69.84 36.32,69.91 36.32,70.01 36.25,70.08 36.1,70.08 36.03,70.15 36.03,70.29 v8(36.01,70.31)
  IN3 w0.064: 41.56,69.13 41.17,69.52 39.09,69.52 39.02,69.59 39.02,69.76 38.96,69.83 38.86,69.83 38.8,69.76 38.8,69.59 38.73,69.52 38.63,69.52 38.56,69.59 38.56,69.76 38.5,69.83 38.4,69.83 38.34,69.76 38.34,69.59 38.27,69.52
M_0_DQ36: length 15
  IN3 w0.06: v8(46.85,67.27) 46.86,67.26 47.78,67.26 47.85,67.19 47.85,67.1 47.78,67.03 46.58,67.03 46.5,67.11 46.5,67.39 46.42,67.47 46.08,67.47 45.91,67.43 45.78,67.39 44.75,67.39 43.13,69.01 41.98,69.01 41.56,69.43 ; v8(36.26,69.56) 36.26,69.46 36.3,69.41 36.41,69.41 36.67,69.67 36.85,69.67 36.93,69.75 36.93,69.95 37,70.03 38.27,70.03
  IN3 w0.064: 38.27,70.03 39.04,70.03 39.34,69.72 41.27,69.72 41.56,69.43
  BOTTOM w0.114: U23.N16 v8(36.26,69.56)
M_0_DQ37: length 15.3
  IN3 w0.06: v8(35.01,71.31) 35.03,71.28 35.03,71.19 34.99,71.15 34.74,71.15 34.62,71.03 34.62,70.72 34.74,70.59 34.74,70.49 34.62,70.36 34.62,70.26 34.72,70.16 34.72,70.04 34.62,69.94 34.62,69.82 34.72,69.72 34.72,69.64 34.62,69.53 34.62,69.45 34.72,69.35 34.72,69.23 34.62,69.13 34.62,69.06 34.66,69.01 ; 42.85,67.64 42.9,67.64 43.69,66.85 43.75,66.85 43.79,66.89 43.88,66.89 43.94,66.83 43.94,66.74 43.91,66.7 43.91,66.61 43.97,66.54 44.29,66.54 44.46,66.37 44.57,66.37 44.65,66.45 44.78,66.45 44.85,66.37 44.98,66.37 45.06,66.45 45.16,66.45 45.26,66.35 45.36,66.35 v8(45.44,66.43)
  IN3 w0.064: 34.66,69.01 36.03,67.64 42.85,67.64
M_0_DQ38: length 16.2
  IN3 w0.06: 42.85,67.45 42.88,67.45 43.91,66.42 44.24,66.42 44.44,66.23 45.73,66.23 45.93,66.43 v8(46,66.43) ; 34.47,69.01 34.47,71.05 34.92,71.51 35.31,71.51 v8(35.51,71.31)
  IN3 w0.064: 34.47,69.01 34.47,68.93 35.95,67.45 42.85,67.45
M_0_DQ39: length 15.9
  IN3 w0.06: v8(36.01,70.81) 36.01,70.81 36.01,71.52 36.07,71.58 36.22,71.58 36.27,71.53 36.27,70.61 36.17,70.51 35.93,70.51 35.8,70.38 35.8,70.21 35.89,70.12 35.89,69.32 36.19,69.02 37.21,69.02 37.38,69.19 38.27,69.19 ; 41.56,68.86 41.69,68.73 43,68.73 44.58,67.15 45.83,67.15 45.97,67.2 46.08,67.2 46.57,66.71 v8(46.85,66.71)
  IN3 w0.064: 38.27,69.19 38.41,69.33 41.09,69.33 41.42,69 41.56,68.86
M_0_DQ40: length 14
  IN4 w0.06: v8(34.76,69.56) 34.85,69.47 34.85,69.29 34.76,69.2 34.76,69.08 35.07,68.76 35.07,68.61 ; 41.17,68.56 41.22,68.51 41.22,68.38 41.3,68.3 41.83,68.3 42.62,67.51 43.51,67.51 43.63,67.39 44.42,67.39 44.5,67.47 44.79,67.47 v8(44.87,67.56)
  IN4 w0.064: 35.07,68.61 35.07,68.53 35.15,68.45 37.82,68.45 38.28,68.91 38.76,68.91 38.83,68.99 38.83,69.03 38.92,69.11 39.03,69.11 39.09,69.06 39.09,68.98 39.15,68.91 39.25,68.91 39.32,68.98 39.32,69.08 39.39,69.15 39.49,69.15 39.57,69.08 39.57,68.99 39.64,68.91 39.74,68.91 39.82,68.99 39.82,69.08 39.9,69.15 40,69.15 40.07,69.08 40.07,68.99 40.15,68.91 40.25,68.91 40.33,68.99 40.33,69.08 40.4,69.15 40.5,69.15 40.58,69.08 40.58,68.99 40.66,68.91 40.76,68.91 40.84,68.99 40.84,69.06 40.92,69.14 41.04,69.14 41.12,69.06 41.12,68.61 41.17,68.56
  BOTTOM w0.114: U23.K16 v8(34.76,69.56)
M_0_DQ41: length 14.1
  IN4 w0.06: 41.35,68.73 41.35,68.53 41.42,68.45 41.91,68.45 42.01,68.35 42.11,68.35 42.21,68.44 42.3,68.44 42.37,68.37 42.37,68.27 42.28,68.18 42.28,68.08 42.35,68.01 42.45,68.01 42.54,68.1 42.64,68.1 42.71,68.03 42.71,67.93 42.62,67.84 42.62,67.74 42.69,67.67 42.79,67.67 42.85,67.72 42.97,67.72 43.05,67.64 43.61,67.64 43.73,67.52 44.19,67.52 v8(44.27,67.59) ; 35.42,68.65 35.01,69.05 35.01,69.2 35.1,69.29 35.1,69.45 35.01,69.55 v8(35.01,69.81)
  IN4 w0.064: 35.42,68.65 37.74,68.65 38.28,69.18 38.71,69.18 38.88,69.34 39.33,69.34 39.41,69.42 39.41,69.73 39.48,69.8 39.59,69.8 39.66,69.73 39.66,69.42 39.74,69.34 39.84,69.34 39.91,69.42 39.91,69.75 39.99,69.83 40.09,69.83 40.17,69.75 40.17,69.42 40.24,69.34 41.27,69.34 41.35,69.27 41.35,68.73
M_0_DQ42: length 14.4
  IN4 w0.06: 42.14,69.42 42.21,69.34 42.21,69.14 42.64,68.71 43.36,68.71 44.15,67.91 44.38,67.91 44.53,68.07 44.81,68.07 v8(44.87,68.12) ; v8(34.51,71.31) 34.76,71.06 35.07,71.06 35.25,70.88 35.25,70.72 35.43,70.54 35.66,70.54 35.76,70.44 35.76,70.18 35.86,70.08 36.67,70.08 36.75,70 36.75,69.7 36.88,69.57 37.41,69.57
  IN4 w0.064: 42.14,69.42 41.6,69.95 40.79,69.95 40.66,70.09 40.66,70.89 40.59,70.97 39.51,70.97 39.43,70.89 39.43,70.52 39.34,70.44 38.96,70.44 38.68,70.16 38.68,69.95 38.48,69.75 37.94,69.75 37.77,69.57 37.41,69.57
M_0_DQ43: length 13.6
  IN4 w0.06: v8(45.15,67.84) 44.87,67.84 44.65,67.62 44.53,67.62 44.5,67.64 44.35,67.79 44.18,67.79 44.11,67.72 44.02,67.64 43.82,67.64 43.68,67.77 43.18,67.77 42.29,68.66 41.9,68.66 41.82,68.73 ; 36.67,68.84 35.52,68.84 35.24,69.11 35.24,69.94 35.01,70.17 v8(35.01,70.31)
  IN4 w0.064: 41.82,68.73 41.55,69 41.55,69.42 41.42,69.55 40.46,69.55 40.38,69.62 40.38,69.83 40.18,70.03 39.34,70.03 39.21,69.9 39.21,69.62 39.14,69.55 38.81,69.55 38.64,69.37 38.2,69.37 37.66,68.84 36.67,68.84
M_0_DQ44: length 14.9
  IN4 w0.06: 41.27,67.21 41.21,67.27 41.17,67.27 ; 42.19,66.85 43.05,66.85 43.16,66.74 43.91,66.74 v8(43.95,66.71) ; 33.96,70.05 v8(34.26,70.05)
  IN4 w0.064: 41.27,67.21 41.83,67.21 42.19,66.85 ; 33.96,70.05 33.7,69.8 33.7,69.11 33.63,69.04 33.55,69.04 33.47,68.96 33.47,68.86 33.55,68.78 33.78,68.78 33.86,68.71 33.86,68.61 33.78,68.53 33.57,68.53 33.5,68.46 33.5,68.35 33.57,68.28 33.78,68.28 33.85,68.2 33.85,68 34.58,67.27 40.05,67.27 40.12,67.35 40.12,67.52 40.19,67.59 40.3,67.59 40.37,67.52 40.37,67.35 40.45,67.27 41.17,67.27
  BOTTOM w0.114: U23.K15 34.51,70.3 v8(34.26,70.05)
M_0_DQ45: length 14.8
  IN4 w0.06: v8(34.01,70.31) 33.3,69.6 ; 41.17,67.08 41.78,67.08 42.14,66.73 43,66.73 43.13,66.6 43.68,66.6 43.78,66.5 44.05,66.5 44.17,66.63 44.39,66.63 44.59,66.43 v8(44.87,66.43)
  IN4 w0.064: 41.17,67.08 34.49,67.08 33.27,68.3 33.27,69.57 33.3,69.6
M_0_DQ46: length 14.6
  IN4 w0.06: 41.17,67.46 41.2,67.46 41.32,67.34 41.91,67.34 42.26,66.98 43.18,66.98 43.25,66.91 44.03,66.91 44.18,66.75 44.35,66.75 44.39,66.79 44.5,66.91 44.67,66.91 44.87,66.71 v8(45.15,66.71) ; v8(34.01,69.81) 33.87,69.66
  IN4 w0.064: 41.17,67.46 40.66,67.46 40.59,67.54 40.59,67.64 40.43,67.79 39.99,67.79 39.91,67.72 39.91,67.54 39.83,67.46 39.73,67.46 39.66,67.54 39.66,67.72 39.58,67.79 39.48,67.79 39.4,67.72 39.4,67.54 39.33,67.46 34.67,67.46 34.06,68.07 34.06,68.99 33.83,69.22 33.83,69.63 33.87,69.66
M_0_DQ47: length 14.5
  IN4 w0.06: v8(34.51,70.81) 34.76,70.55 35.12,70.55 35.25,70.42 35.25,70.18 35.38,70.05 35.58,70.05 35.73,69.9 35.73,69.17 35.86,69.04 36.88,69.04 ; 42.14,68.89 42.19,68.84 42.31,68.84 43.23,67.92 43.86,67.92 v8(43.95,67.84)
  IN4 w0.064: 42.14,68.89 42.06,68.96 42.06,69.22 41.53,69.75 40.73,69.75 40.46,70.02 40.46,70.69 40.38,70.77 40.27,70.77 40.19,70.69 40.19,70.3 40.11,70.22 40.01,70.22 39.94,70.3 39.94,70.69 39.86,70.77 39.75,70.77 39.67,70.69 39.67,70.31 39.6,70.23 39.09,70.23 39.01,70.16 39.01,69.83 38.93,69.75 38.75,69.75 38.56,69.56 38.11,69.56 37.59,69.04 36.88,69.04
M_0_DQ48: length 23
  IN4 w0.06: v8(30.77,70.07) 30.77,69.71 30.88,69.6 ; 41.17,66.51 41.19,66.51 41.39,66.32 41.83,66.32 42.26,65.89 43.62,65.89 43.75,66.02 44.18,66.02 44.22,66.06 44.39,66.06 44.52,65.93 44.65,65.93 44.8,66.08 45.08,66.08 v8(45.15,66.14)
  IN4 w0.064: 41.17,66.51 39.64,66.51 39.46,66.33 38.76,66.33 38.58,66.51 37.61,66.51 37.43,66.33 37.3,66.33 37.13,66.51 36.05,66.51 35.87,66.33 35.68,66.33 35.5,66.51 34.34,66.51 34.17,66.33 34,66.33 33.52,66.82 33,66.82 32.52,66.34 32.38,66.34 32.31,66.42 32.31,66.71 32.23,66.79 32.1,66.79 32.03,66.87 32.03,66.98 32.1,67.06 32.5,67.06 32.57,67.13 32.57,67.24 32.5,67.31 32.08,67.31 32,67.39 32,67.49 32.08,67.57 32.5,67.57 32.57,67.64 32.57,67.74 32.5,67.82 32.08,67.82 32,67.89 32,68 32.08,68.07 32.5,68.07 32.57,68.15 32.57,68.25 32.5,68.33 32.08,68.33 32,68.4 32,68.51 32.08,68.58 32.5,68.58 32.57,68.66 32.57,68.76 32.5,68.84 32.1,68.84 31.86,69.08 31.41,69.08 30.88,69.6
  BOTTOM w0.114: U23.C15 v8(30.77,70.07)
M_0_DQ49: length 24.3
  IN4 w0.06: v8(30.51,69.81) 30.51,69.69 30.6,69.6 ; v8(44.3,65.86) 44.12,65.86 44.08,65.9 43.8,65.9 43.62,65.71 42.19,65.71 41.7,66.19 41.34,66.19 41.22,66.32 41.17,66.32
  IN4 w0.064: 41.17,66.32 39.72,66.32 39.54,66.14 38.68,66.14 38.5,66.32 37.69,66.32 37.51,66.14 37.22,66.14 37.05,66.32 36.12,66.32 35.95,66.14 35.6,66.14 35.42,66.32 34.42,66.32 34.24,66.14 33.92,66.14 33.44,66.63 33.14,66.63 33.04,66.53 33.04,66.37 32.99,66.32 32.77,66.32 32.59,66.14 32.3,66.14 32.12,66.32 31.24,66.32 31.16,66.4 31.16,66.5 31.24,66.58 31.77,66.58 31.85,66.65 31.85,66.76 31.77,66.83 31.24,66.83 31.16,66.91 31.16,67.01 31.24,67.08 31.77,67.08 31.85,67.16 31.85,67.26 31.77,67.34 31.24,67.34 31.16,67.41 31.16,67.52 31.24,67.59 31.77,67.59 31.85,67.67 31.85,67.77 31.77,67.85 31.24,67.85 31.16,67.92 31.16,68.02 31.24,68.1 31.77,68.1 31.85,68.17 31.85,68.28 31.77,68.35 31.24,68.35 31.16,68.43 31.16,68.53 31.24,68.61 31.77,68.61 31.85,68.68 31.85,68.81 31.77,68.88 31.14,68.88 31.06,68.96 31.06,69.14 30.6,69.6
M_0_DQ50: length 23.4
  IN4 w0.06: 41.17,64.49 41.65,64.49 41.73,64.42 42.01,64.42 42.08,64.49 43.71,64.49 43.96,64.75 44.04,64.75 44.18,64.89 44.42,64.89 44.59,64.73 v8(44.87,64.73) ; 29.51,70.81 30.01,71.31 v8(30.51,71.31)
  IN4 w0.064: 29.51,70.81 28.97,70.26 28.97,65.41 29.61,64.77 40.46,64.77 40.74,64.49 41.17,64.49
M_0_DQ51: length 24.2
  IN4 w0.06: 31.22,69.6 v8(31.01,69.81) ; v8(44.59,66.14) 44.54,66.19 44.18,66.19 44.13,66.14 43.68,66.14 43.48,66.35 43.11,66.35 43.04,66.28 43.04,66.14 42.97,66.07 42.87,66.07 42.8,66.14 42.8,66.28 42.73,66.35 42.63,66.35 42.56,66.28 42.56,66.14 42.49,66.07 42.39,66.07 42.32,66.14 42.32,66.28 42.25,66.35 42.11,66.35 41.65,66.8 41.3,66.8 41.2,66.7 41.17,66.7
  IN4 w0.064: 31.22,69.6 31.27,69.55 31.54,69.55 32.23,70.23 32.23,71.48 32.31,71.55 32.69,71.55 32.76,71.48 32.76,70.38 31.96,69.58 31.96,69.25 32.15,69.06 32.69,69.06 32.76,68.99 32.76,68.11 32.84,68.03 32.99,68.03 33.07,67.95 33.07,67.85 32.99,67.78 32.83,67.78 32.76,67.71 32.76,67.6 32.84,67.53 33.5,67.53 33.58,67.45 33.58,67.35 33.5,67.27 32.84,67.27 32.76,67.2 32.76,67.08 32.83,67.01 33.75,67.01 33.83,66.94 33.83,66.78 34,66.61 34.17,66.61 34.26,66.7 38.66,66.7 38.84,66.52 39.38,66.52 39.56,66.7 41.17,66.7
M_0_DQ52: length 24.1
  IN4 w0.06: v8(44.87,65.86) 44.79,65.78 44.5,65.78 44.39,65.66 44.15,65.66 44.03,65.78 43.85,65.78 43.66,65.58 42.11,65.58 ; v8(30.26,70.04) 30.26,69.64
  IN4 w0.064: 42.11,65.58 41.65,66.04 41.28,66.04 41.19,66.13 39.8,66.13 39.62,65.95 38.6,65.95 38.43,66.13 37.77,66.13 37.59,65.95 37.15,65.95 36.97,66.13 36.2,66.13 36.03,65.95 35.52,65.95 35.34,66.13 34.5,66.13 34.32,65.95 33.85,65.95 33.67,66.13 32.85,66.13 32.67,65.95 32.22,65.95 32.04,66.13 31.15,66.13 31.04,66.02 30.5,66.02 30.43,66.09 30.43,66.23 30.5,66.31 30.88,66.31 30.96,66.38 30.96,66.49 30.88,66.56 30.6,66.56 30.53,66.64 30.53,66.74 30.6,66.82 30.88,66.82 30.96,66.89 30.96,67 30.88,67.07 30.6,67.07 30.53,67.15 30.53,67.25 30.6,67.33 30.88,67.33 30.96,67.4 30.96,67.51 30.88,67.58 30.6,67.58 30.52,67.65 30.52,67.76 30.6,67.83 30.88,67.83 30.96,67.91 30.96,68.01 30.88,68.09 30.6,68.09 30.53,68.16 30.53,68.27 30.6,68.34 30.88,68.34 30.96,68.42 30.96,68.52 30.88,68.6 30.6,68.6 30.53,68.67 30.53,68.78 30.6,68.85 30.78,68.85 30.86,68.92 30.86,69.03 30.78,69.1 30.6,69.1 30.52,69.18 30.52,69.38 30.26,69.64
  BOTTOM w0.114: v8(30.26,70.04) 30.51,70.29 U23.B15
M_0_DQ53: length 23.6
  IN4 w0.06: 41.17,66.89 41.22,66.89 41.25,66.92 41.28,66.92 41.29,66.93 41.73,66.93 42.19,66.47 43.61,66.47 43.71,66.37 44.17,66.37 44.22,66.43 v8(44.3,66.43) ; v8(31.01,70.81) 31.24,71.04 31.24,72.01 31.31,72.09 32.23,72.09 32.31,72.16 32.31,73.18 32.38,73.26 32.48,73.26 32.56,73.18 32.56,72.18 32.63,72.11 32.73,72.11 32.8,72.18 32.8,73.18 32.87,73.26 33.17,73.26 33.25,73.18 33.25,69.76 33.08,69.6
  IN4 w0.064: 33.08,69.6 33.08,69.6 33.08,68.22 34.41,66.89 41.17,66.89
M_0_DQ54: length 24.2
  IN4 w0.06: v8(31.01,71.31) 30.76,71.55 29.99,71.55 29.51,71.08 ; 41.17,64.28 42.18,64.28 42.26,64.37 43.74,64.37 43.86,64.25 44.05,64.25 44.27,64.46 v8(44.27,64.69)
  IN4 w0.064: 29.51,71.08 28.78,70.34 28.78,65.33 29.53,64.58 40.37,64.58 40.67,64.28 41.17,64.28
M_0_DQ55: length 24.2
  IN4 w0.06: v8(30.51,70.81) 30.73,70.81 30.81,70.88 30.81,71.02 30.73,71.1 29.99,71.1 29.77,70.87 29.77,70.79 29.51,70.54 ; v8(44.59,65.01) 44.23,65.01 44.23,65.01 44.13,65.01 44.05,64.93 43.51,64.93 43.43,64.86 43.43,64.72 43.35,64.64 42.67,64.64 42.6,64.71 42.6,64.86 42.53,64.93 42.43,64.93 42.36,64.86 42.36,64.71 42.29,64.64 42.19,64.64 42.12,64.71 42.12,64.86 42.05,64.93 41.6,64.93 41.53,64.86 41.53,64.75 41.46,64.68 41.36,64.68 41.29,64.75 41.29,64.86
  IN4 w0.064: 41.29,64.86 41.22,64.93 41.03,64.93 40.86,65.1 40.71,65.1 40.57,64.96 29.69,64.96 29.16,65.49 29.16,70.18 29.51,70.54
M_0_DQ56: length 21.8
  IN3 w0.06: v8(32.01,70.81) 31.92,70.72 31.66,70.72 31.6,70.77 31.5,70.77 31.43,70.7 31.43,70.59 31.62,70.4 31.62,70.31 31.56,70.24 31.47,70.24 31.26,70.45 31.17,70.45 31.11,70.38 31.11,70.29 31.39,70.01 31.39,69.92 31.32,69.86 31.23,69.86 30.96,70.13 30.86,70.13 30.79,70.07 30.79,69.97 31.06,69.7 31.06,69.6 30.98,69.52 30.86,69.52 30.78,69.45 30.78,69.01 ; 42.85,65.32 42.99,65.32 43.35,64.95 45.66,64.95 v8(45.72,65.01)
  IN3 w0.064: 42.85,65.32 33.25,65.32 30.78,67.79 30.78,69.01
M_0_DQ57: length 22.2
  IN3 w0.06: 33.05,69.01 33.05,69.36 33.35,69.65 33.7,69.65 33.78,69.72 33.78,70.94 33.71,71.02 33.62,71.02 33.55,70.94 33.55,70.48 33.23,70.16 32.84,70.16 v8(32.75,70.06) ; v8(46.85,66.14) 47.1,66.4 47.44,66.4 47.52,66.48 47.52,66.78 47.43,66.87 47.3,66.87 46.37,65.94 46.2,65.94 46.08,66.06 45.92,66.06 45.84,65.98 44.33,65.98 44.2,66.12 43.81,66.12 42.86,67.07 42.85,67.07
  IN3 w0.064: 33.05,69.01 33.05,68.75 33.45,68.35 33.89,68.35 34.15,68.61 34.26,68.61 35.8,67.07 42.85,67.07
  BOTTOM w0.114: U23.F15 v8(32.75,70.06)
M_0_DQ58: length 20.8
  IN3 w0.06: 42.85,65.51 43.02,65.51 43.43,65.09 45.52,65.09 45.64,65.21 45.8,65.21 45.94,65.08 46.07,65.08 46.5,65.51 46.6,65.51 46.68,65.43 46.68,65.37 46.61,65.29 v8(46.57,65.29) ; v8(32.01,70.31) 32.01,70.51 31.95,70.56 31.85,70.56 31.77,70.49 31.77,70.03 30.97,69.23 30.97,69.01
  IN3 w0.064: 30.97,69.01 30.97,67.87 33.33,65.51 42.85,65.51
