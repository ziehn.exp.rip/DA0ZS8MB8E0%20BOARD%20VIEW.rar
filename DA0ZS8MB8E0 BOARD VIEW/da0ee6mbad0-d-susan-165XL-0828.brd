# Allegro board da0ee6mbad0-d-susan-165XL-0828.brd (continued)
## Copper pours and planes (outline as drawn) (continued)
+3V3PCU on IN3 (solid shape): 109.24,64.67 109.24,64.54 109.37,64.42 109.37,63.53 109.38,63.51 109.24,63.37 108.35,63.37 108.2,63.53 108.2,64.44 108.56,64.8 109.12,64.8
+3V3PCU on IN4 (solid shape): outline of 2156 points within 3.73,35.89 111.66,74.53
+3V3S5 on TOP (solid shape): 94.99,68.73 95.03,68.72 95.04,68.68 95.04,64.85 95.7,64.19 95.7,62.89 95.04,62.23 95.04,59.54 95.45,59.13 98.04,59.13 99.34,57.84 99.34,56.01 100.61,54.74 100.61,51.03 99.23,49.66 98.17,49.66 97.96,49.86 97.96,50.98 98.14,51.16 98.85,51.16 99.51,51.82 99.51,54.31 97.53,56.29 97.53,57.86 97.33,58.07 93.37,58.07 92.94,58.5 92.94,61.16 92.86,61.24 85.04,61.24 84.71,60.91 83.26,60.91 83.22,60.93 83.21,60.96 83.21,61.77 83.13,61.85 80.54,61.85 80.51,61.88 80.51,62.51 80.57,62.56 81.02,62.56 81.28,62.31 83.61,62.31 83.87,62.05 93.37,62.05 93.65,61.77 93.65,60.5 93.77,60.38 94.51,60.38 94.56,60.43 94.56,62.54 95.2,63.17 95.2,63.91 94.56,64.54 94.56,68.68 94.58,68.72 94.61,68.73
+3V3S5 on BOTTOM (solid shape): 65.45,73.26 65.45,72.77 65.8,72.43 65.8,71.15 65.43,71.15 65.43,72.14 65.27,72.29 64.33,72.29 64.26,72.37 64.26,72.7 64.84,73.28 65.43,73.28
+3V3S5 on BOTTOM (solid shape): 105.48,63.7 105.48,63.35 105.5,63.34 105.5,63.21 105.81,62.89 106.47,62.89 106.5,62.92 109.32,62.92 109.5,62.74 109.5,61.88 109.42,61.8 106.8,61.8 106.68,61.67 106.68,61.11 106.59,61.03 105.52,61.03 105.25,61.29 105.25,61.88 105.1,62.03 104.09,62.03 104.01,62.1 104.01,63.68 104.16,63.83 105.36,63.83
+3V3S5 on BOTTOM (solid shape): 96.52,62.43 96.52,55.21 96.31,54.89 96.52,54.57 96.52,53.82 96.31,53.49 96.52,53.17 96.52,51.11 96.64,50.98 97.91,50.98 98.12,51.18 98.12,51.41 98.19,51.49 98.75,51.49 98.83,51.41 98.83,48.9 98.45,48.52 97.05,48.52 96.9,48.67 96.9,48.87 96.72,49.05 95.27,49.05 94.74,49.58 94.74,61.55 94.43,61.85 89.02,61.85 88.67,62.21 87.22,62.21 87.14,62.28 87.14,62.43 87.19,62.49 89.33,62.49 89.46,62.61 92.96,62.61 93.07,62.73 96.22,62.73
+3V3S5 on IN1 (solid shape): outline of 324 points within 20.57,35.41 99.03,51.28
+3V3S5 on IN4 (solid shape): outline of 986 points within 62.4,49.76 109.62,82.2
+3V3S5_SOC on TOP (solid shape): 54.63,71.65 54.63,69.5 54.38,69.5 54.38,71.02 54.12,71.27 53.54,71.27 53.51,71.3 53.51,71.76 53.54,71.78 54.51,71.78
+3V3SX on BOTTOM (solid shape): 65.79,67.9 66.08,67.9 66.08,68.86 66.44,68.86 66.44,67.08 66.34,66.98 65.43,66.98 65.43,68.84 65.45,68.86 65.79,68.86
+3V3SX on IN3 (solid shape): 66.44,69.22 66.44,68.58 66.39,68.53 63.67,68.53 63.57,68.63 63.57,69.19 63.67,69.29 66.37,69.29
+3VPCU_EC on IN1 (solid shape): outline of 339 points within 111.53,56.06 116.71,63.7
+3VPCU_EC_PWR on TOP (solid shape): 110.79,65.25 110.79,64.34 110.58,64.12 109.83,64.12 109.7,64.25 109.7,65.2 109.8,65.3 110.74,65.3
+3VPCU_EC_PWR on IN2 (solid shape): 112.67,64.42 112.67,64.03 112.42,63.78 110.13,63.78 109.75,64.16 109.75,65.15 109.88,65.27 111.81,65.27
+3VPCU_EC_PWR on IN3 (solid shape): 112.42,64.59 112.42,63.3 112.29,63.17 111.63,63.17 111.4,63.4 111.4,64.62 111.63,64.84 111.67,64.87 111.7,64.9 112.11,64.9
+5V on TOP (solid shape): 99.36,54.26 99.36,51.87 98.8,51.31 97.94,51.31 97.76,51.13 97.76,50.47 97.66,50.37 96.97,50.37 96.82,50.22 96.82,49.66 96.59,49.43 93.82,49.43 93.62,49.63 93.62,51.94 93.8,52.12 96.16,52.12 96.75,52.71 98.12,52.71 98.19,52.78 98.19,54.56 98.42,54.79 98.83,54.79
+5V on BOTTOM (solid shape): 112.29,79.27 112.29,78.51 112.16,78.39 111.4,78.39 111.27,78.51 111.27,79.27 111.4,79.4 112.16,79.4
+5V on IN1 (solid shape): 99.54,54.59 99.54,53.85 99.29,53.6 98.42,53.6 98.27,53.75 98.27,54.74 98.57,55.04 99.08,55.04
+5V on IN1 (solid shape): 102.71,78.49 102.71,76.91 102.51,76.71 101.75,76.71 101.62,76.84 101.62,78.49 101.83,78.69 102.51,78.69
+5V on IN1 (solid shape): 98.68,77.85 98.68,76.71 97.79,75.82 94.18,75.82 91.51,73.15 90.7,73.15 88.69,71.15 86.92,71.15 86.84,71.22 86.84,71.76 86.94,71.86 88.54,71.86 90.5,73.81 91.23,73.81 91.39,73.97 91.64,74.07 91.74,74.32 93.95,76.53 97.08,76.53 97.91,77.37 97.91,77.88 98.04,78 98.52,78
+5V on IN1 (solid shape): 123.78,80.59 123.92,80.44 124.13,80.39 124.15,80.39 126.01,78.54 126.01,73.13 126.03,73.1 129.18,73.1 129.77,73.69 137.82,73.69 139.93,71.58 145.61,71.58 146,71.96 148.36,71.96 148.43,72.04 148.45,72.04 148.61,72.12 148.69,72.27 148.69,72.29 148.74,72.34 148.74,75.59 149.88,76.73 151,76.73 151,76.69 151.28,76.45 151.56,76.69 151.56,76.73 154.07,76.73 154.2,76.61 154.2,76.1 154.06,75.96 150.12,75.96 149.36,75.2 149.36,71.92 148.87,71.43 146.33,71.43 146,71.1 139.54,71.1 137.49,73.15 130.53,73.15 129.71,72.34 126.62,72.34 125.93,71.65 125.93,61.01 125.65,60.73 121.17,60.73 120.98,60.84 120.79,60.73 118.06,60.73 118.01,60.78 118.01,61.42 118.03,61.44 125.23,61.44 125.41,61.62 125.41,72.35 125.22,72.54 125.22,78.03 123.49,79.76 113.74,79.76 112.19,78.21 111.32,78.21 111.2,78.34 111.2,78.82 112.92,80.54 113.31,80.54 113.61,80.45 113.87,80.62 123.77,80.62
+5V on IN1 (solid shape): outline of 276 points within 72.09,55.75 87.37,69.11
+5V on IN2 (solid shape): 112.29,79.53 112.29,78.51 111.91,78.13 111.15,78.13 110.19,79.08 103.46,79.08 100.99,76.61 98.19,76.61 98.04,76.76 98.04,77.76 98.2,77.92 100.39,77.92 100.47,78 100.86,78 103.06,80.21 111.61,80.21
+5V on IN3 (solid shape): 112.29,79.27 112.29,78.64 111.91,78.26 111.15,78.26 110.89,78.51 110.89,79.53 111.02,79.66 111.91,79.66
+5V_SRC on TOP (solid shape): 98.05,55.03 98.05,53.74 98.07,53.72 98.07,52.94 97.99,52.86 96.67,52.86 96.19,52.38 94.56,52.38 94.54,52.4 94.54,53.25 94.87,53.57 94.87,54.05 96.08,55.27 97.81,55.27
+5V_SRC on BOTTOM (solid shape): 96.16,77.75 96.16,65.97 96.57,65.56 98.07,65.56 98.19,65.43 98.19,64.67 97.94,64.42 96.8,64.42 96.67,64.54 96.16,64.54 96.01,64.39 95.68,64.39 94.28,65.79 94.28,65.94 94.13,66.09 89.68,66.09 87.8,64.21 86.76,64.21 86.74,64.24 86.74,64.47 86.76,64.49 87.63,64.49 88.49,65.36 88.49,65.66 89.76,66.93 94.13,66.93 94.64,67.44 94.64,76.94 94.92,77.22 94.92,77.78 95.02,77.88 96.03,77.88
+5V_SRC on IN4 (solid shape): outline of 183 points within 94.38,53.24 97.76,65.43
+V1.0S_GPIO on TOP (solid shape): 56.26,60.35 56.26,59.46 56.51,59.21 56.84,59.21 56.84,58.47 56.74,58.37 56.74,57.43 55.6,57.43 55.5,57.53 55.5,60.38 55.55,60.43 56.18,60.43
+V1.0S_GPIO on BOTTOM (solid shape): 59.56,61.04 60.27,61.04 60.55,60.76 60.55,60.61 60.45,60.5 59.66,60.5 59.31,60.86 59.25,60.86 59.13,60.99 59.13,61.14 59.2,61.22 59.38,61.22
+V1.0S_GPIO on BOTTOM (solid shape): 59.53,59.92 60.88,59.92 61.06,59.74 61.06,59.13 60.98,59.06 60.09,59.06 59.74,59.41 59.64,59.41 59.43,59.62 59.36,59.62 59.13,59.84 59.13,59.97 59.23,60.07 59.38,60.07
+V1.0S_GPIO on IN2 (solid shape): 56.61,60.71 56.61,60.28 57.07,59.82 58.16,59.82 58.98,60.63 60.68,60.63 60.97,60.34 60.97,59.32 60.27,58.62 55.75,58.62 55.52,58.85 55.52,60.22 55.9,60.61 55.9,60.91 56.41,60.91
+V1.0S_GPIO on IN3 (solid shape): 56.33,60.96 56.33,59.95 56.11,59.72 55.67,59.72 55.44,59.95 55.44,61.04 55.5,61.09 56.21,61.09
+V1.0S_GPIO on IN4 (solid shape): 61.01,60.81 61.01,59.26 60.83,59.08 60.07,59.08 59.89,59.26 59.89,60.94 60.04,61.09 60.73,61.09
+V1.0S_GUIO on TOP (solid shape): 60.4,68.35 60.52,68.23 61.06,68.23 61.06,67.72 60.07,67.72 58.95,68.84 55.55,68.84 55.52,68.86 55.52,69.11 55.55,69.14 58.85,69.14 59.2,69.5 60.4,69.5
+V1.0SX_DIGDP on TOP (solid shape): 57.6,61.52 57.38,61.29 57.38,60.61 56.87,60.61 56.77,60.71 56.77,61.9 56.66,62 55.67,62 55.62,62.05 55.62,62.31 55.67,62.36 57.6,62.36
+V1.8S_5M_R on BOTTOM (solid shape): 19.61,62.1 19.78,61.93 19.78,60.3 20.44,59.64 20.44,55.37 20.34,55.27 19.96,55.27 19.71,55.53 19.71,59.26 19.3,59.67 19.3,62.79 19.61,62.79
+V1.8U_LPDDR3 on TOP (solid shape): 39.62,77.5 39.62,76.86 27.5,76.86 27.1,76.46 27.1,65.75 27.14,65.71 37.26,65.71 37.74,66.19 37.74,69.88 38,70.13 39.39,70.13 39.52,70 39.52,69.5 38.63,69.5 38.5,69.37 38.5,60.73 39.14,60.1 39.39,60.1 39.52,59.97 39.52,59.34 38.25,59.34 37.87,59.72 37.87,63.15 37.33,63.68 28.52,63.68 27.76,62.92 27.76,53.09 28.42,52.43 39.6,52.43 39.6,51.18 39.42,51 38.93,51 38.83,50.9 26.21,50.9 25.55,51.56 25.55,77.67 39.44,77.67
+V2.8_5M_R on BOTTOM (solid shape): 21.33,62.56 21.33,61.39 21.51,61.22 22.12,61.22 22.25,61.09 22.25,56.97 22.17,56.9 21.69,56.9 21.61,56.97 21.61,59.95 21.36,60.2 21.33,60.2 20.67,60.86 20.67,61.95 20.49,62.13 19.91,62.13 19.91,62.79 21.1,62.79
+V3.3_VUSB2 on BOTTOM (solid shape): 61.06,69.93 63.01,69.93 63.09,69.85 63.09,69.52 63.22,69.39 63.22,68.73 62.71,68.73 62.71,69.34 62.51,69.55 59.56,69.55 59.45,69.46 59.4,69.39 59.38,69.37 59.26,69.37 59.23,69.4 59.19,69.43 59.13,69.5 59.13,69.6 59.16,69.63 59.16,69.63 59.23,69.68 59.28,69.75 59.29,69.76 59.38,69.85 59.4,69.85 59.5,69.88 59.58,69.95 59.6,69.98 61.01,69.98
+V3.3A_SRC on BOTTOM (solid shape): 105.71,70.09 105.71,68.84 106.19,68.35 106.19,65.56 106.7,65.05 106.7,63.27 106.58,63.15 105.94,63.15 105.81,63.27 105.81,64.16 105.31,64.67 104.04,64.67 103.53,65.18 103.53,66.57 104.42,67.46 104.42,69.99 104.59,70.17 105.64,70.17
+V3.3S_ACCEL on BOTTOM (solid shape): 171.22,75.34 171.22,73.31 171.09,73.18 169.82,73.18 169.16,73.84 169.16,74.4 168.92,74.64 167.34,74.64 167.28,74.7 167.28,75.34 167.54,75.59 170.96,75.59
+V3.3S_GYRO on BOTTOM (solid shape): 101.11,43.08 101.11,42.34 101.09,42.32 100.63,42.32 100.61,42.34 100.61,42.83 100.4,43.03 97.84,43.03 97.66,42.85 97.66,42.44 97.56,42.34 96.85,42.34 96.67,42.17 96.67,38.63 96.5,38.47 96.12,38.47 95.83,38.76 95.12,38.76 94.94,38.58 93.82,38.58 93.6,38.81 92.99,38.81 92.88,38.91 92.88,39.35 92.94,39.4 95.65,39.4 95.91,39.65 95.91,42.57 96.67,43.33 96.69,43.33 96.77,43.41 100.78,43.41
+V3.3S_SENSOR on IN4 (solid shape): 87.68,44.83 89.68,44.83 89.71,44.86 90.32,44.86 90.45,44.73 90.45,43.54 90.34,43.44 90.17,43.44 89.4,44.2 88.29,44.2 88.03,44.38 87.77,44.2 87.17,44.2 86.84,44.53 86.81,44.68 86.71,44.8 86.71,45.06 86.84,45.19 87.32,45.19
+VBATBKUP on TOP (solid shape): 82.83,59.54 82.67,59.39 82.67,58.52 81.96,58.52 81.96,59.62 81.89,59.69 78.89,59.69 78.89,60.2 81.94,60.2 82.29,60.56 82.83,60.56
+VDDQ on TOP (solid shape): 85.44,59.74 85.44,59.36 85.87,58.93 85.87,55.42 85.82,55.37 84.83,55.37 84.73,55.48 84.73,59.03 84.81,59.11 84.81,59.74 84.86,59.79 85.39,59.79
+VDDQ on TOP (solid shape): 46.89,66.83 46.89,65.94 46.63,65.94 46.63,66.57 46.5,66.7 44.22,66.7 43.84,66.32 43.84,61.37 43.96,61.24 47.52,61.24 47.65,61.11 47.65,60.61 43.84,60.61 43.71,60.48 43.71,59.08 50.44,52.35 50.44,49.68 50.31,49.56 48.66,49.56 48.41,49.81 48.41,52.35 40.41,60.35 40.41,63.35 40.92,63.35 40.92,62.64 43.2,62.64 43.33,62.76 43.33,66.57 43.71,66.96 46.76,66.96
+VDDQ on BOTTOM (solid shape): 86.18,48.21 86.18,46.41 86.08,46.31 84.78,46.31 84.68,46.41 84.68,48.29 84.83,48.44 85.95,48.44
+VDDQ on BOTTOM (solid shape): 89.61,54.94 89.61,53.47 89.2,53.06 89.2,46.59 89.07,46.46 86.51,46.46 86.38,46.59 86.38,48.31 86.48,48.41 87.68,48.41 88.01,48.74 88.01,53.75 87.75,54 87.75,54.94 87.86,55.04 89.51,55.04
+VDDQ on BOTTOM (solid shape): outline of 124 points within 32.14,54.3 35.87,58.03
+VDDQ on BOTTOM (solid shape): outline of 3464 points within 24.89,48.26 50.59,81.41
+VDDQ on IN2 (solid shape): 86.31,60.89 86.31,59.77 86.15,59.62 86.15,59.35 86.13,59.33 86.13,58.32 85.75,57.94 85.7,57.94 85.57,57.8 85.57,57.08 85.57,57.08 85.57,48.87 86.31,48.13 86.31,47.4 86.15,47.25 85.85,47.25 84.96,48.13 84.96,55.91 84.63,56.24 84.63,59.34 85.65,60.35 85.65,60.94 85.7,60.99 86.2,60.99
+VDDQ on SVCC2 (solid shape): 50.9,50.01 50.98,49.96 51.08,49.94 55.5,49.94 55.54,49.94 55.58,49.95 55.8,49.73 55.85,49.7 55.9,49.68 61.11,49.68 61.17,49.7 61.21,49.73 61.44,49.96 61.61,49.96 61.66,49.94 61.72,49.94 70.65,49.94 72.23,48.36 72.31,48.31 72.41,48.29 86.71,48.29 86.89,48.11 86.89,42.81 86.66,42.57 49.15,42.57 46.76,44.96 46.76,50.34 48.39,51.97 48.92,51.97 48.94,51.97
+VDDQ on IN3 (solid shape): 86.18,47.68 86.18,46.61 85.98,46.41 85.14,46.41 84.76,46.79 84.76,47.75 84.79,47.79 86.07,47.79
+VDDQ on IN3 (solid shape): 35.25,57.15 35.25,56.36 35.27,56.35 35.27,54.96 35.16,54.85 34.5,54.85 34.43,54.93 34.43,56.2 33.79,56.83 30.24,56.83 27.97,56.83 27.86,56.95 27.86,57.55 27.96,57.65 34.76,57.65
+VDDQ on IN3 (solid shape): 35.29,74.82 35.29,74 35.06,73.78 35.06,72.72 35.03,72.65 34.72,72.54 34.62,72.31 34.59,72.25 34.53,72.21 34.37,72.15 34.28,72.01 34.26,71.97 32.29,71.97 31.79,71.47 31.72,71.44 31.65,71.46 31.47,71.52 31.32,71.41 31.31,71.39 31.23,71.39 30.64,70.8 27.75,70.8 27.7,70.85 27.7,71.63 27.88,71.82 30.59,71.82 30.61,71.84 30.67,71.84 30.84,72.01 31.09,72.01 31.29,72.21 31.29,72.39 31.62,72.72 31.62,72.86 31.72,72.96 33.89,72.96 34.34,73.41 34.34,73.78 34.38,73.79 34.64,74.03 34.5,74.35 34.5,74.64 34.76,74.89 35.21,74.89
+VDDQ_VTT on BOTTOM (solid shape): 91.89,57.79 91.89,55.3 91.77,55.17 90.29,55.17 90.17,55.3 90.17,56.24 90.52,56.59 90.52,56.9 90.4,57.02 89.61,57.02 89.51,57.13 89.51,57.74 89.63,57.86 91.82,57.86
+VDDQ_VTT on BOTTOM (solid shape): 26.54,49.94 26.44,49.84 26.44,49.81 25.8,49.81 25.68,49.68 25.68,48.92 25.8,48.79 32.66,48.79 32.79,48.67 32.79,48.29 32.66,48.16 25.17,48.16 25.04,48.29 25.04,50.36 25.8,50.36 25.8,51.37 25.04,51.37 25.04,53.02 25.8,53.02 25.8,53.11 26.54,53.11
+VDDQ_VTT on BOTTOM (solid shape): 32.66,81.31 32.66,80.8 32.53,80.67 25.76,80.67 25.7,80.61 25.7,79.9 26.44,79.9 26.65,79.68 26.65,76.2 26.58,76.13 25.78,76.13 25.73,76.09 25.73,75.27 25.55,75.08 25.04,75.08 24.91,75.21 24.91,76.92 25.07,77.07 25.64,77.07 25.67,77.11 25.67,77.83 25.61,77.9 24.95,77.9 24.91,77.93 24.91,81.31 25.04,81.43 32.53,81.43
+VDDQ_VTT on IN1 (solid shape): outline of 193 points within 24.84,39.88 91.49,77.07
+VDDQ_VTT on IN2 (solid shape): 91.64,55.27 91.64,54.48 91.56,54.41 90.32,54.41 90.29,54.43 90.29,55.25 90.37,55.32 91.59,55.32
+VDDQ_VTT on IN3 (solid shape): 91.67,55.53 91.67,54.97 91.54,54.84 90.45,54.84 90.32,54.97 90.32,55.55 90.37,55.6 91.59,55.6
+VDDQ_VTT on IN4 (solid shape): 87.4,60.76 87.4,59.96 88.19,59.17 90.03,59.17 90.37,58.83 90.37,57.13 90.29,57.05 89.48,57.05 89.43,57.1 89.43,58.32 89.35,58.4 87.7,58.4 87.14,58.95 87.14,59.46 86.76,59.84 86.76,61.27 86.79,61.29 86.86,61.29
AGND on TOP (solid shape): 123.62,77.67 123.62,76.94 123.92,76.63 124.48,76.63 124.86,76.25 124.86,69.62 124.18,68.94 123.54,68.94 123.49,68.99 123.49,72.42 123.52,72.44 124.13,72.44 124.25,72.57 124.25,73.94 124.13,74.07 123.57,74.07 123.49,74.14 123.49,76.23 123.34,76.38 122.35,76.38 122.27,76.46 122.27,77.7 122.3,77.73 123.57,77.73
AGND on BOTTOM (solid shape): 140.93,77.31 140.93,75.4 140.9,75.37 140.9,73.85 140.86,73.82 140.64,73.82 140.6,73.86 140.6,75.35 140.36,75.59 140.36,77.32 140.38,77.34 140.89,77.34
AGND on IN2 (solid shape): 125.47,73.92 125.47,73.1 124.71,72.34 124.71,69.02 124.53,68.84 123.69,68.84 123.47,69.06 123.47,72.04 123.95,72.52 123.97,72.52 124.2,72.75 124.2,73.01 124.06,73.15 124.06,73.36 124.2,73.49 124.2,73.49 124.2,73.89 124.36,74.04 125.35,74.04
AGND on SGND2 (solid shape): 127.22,78.33 127.31,78.28 127.4,78.26 137.3,78.26 138.42,77.14 138.51,77.08 138.6,77.07 141.83,77.07 142.03,76.86 142.03,73.18 140.99,72.14 127.76,72.14 127.66,72.12 127.58,72.06 121.25,65.74 121.2,65.66 121.18,65.56 121.18,64.78 120.95,64.54 117.98,64.54 117.88,64.65 117.88,67.87 118.57,68.55 118.62,68.64 118.64,68.73 118.61,68.86 118.51,68.95 118.51,69.91 118.54,69.93 118.57,69.95 118.75,70.13 119.53,70.13 119.63,70.15 119.71,70.2 119.96,70.46 120.02,70.54 120.04,70.64 120.04,74.83 120.02,74.93 119.96,75.01 119.71,75.26 119.63,75.32 119.53,75.34 116.21,75.34 116.15,75.39 116.13,75.41 116.1,75.43 116.1,76.39 116.19,76.48 116.23,76.61 116.23,77.12 116.21,77.21 116.15,77.3 115.47,77.98 115.47,78.79 115.77,79.09 115.83,79.18 115.85,79.27 115.85,80.44 116.21,80.8 117.24,80.8 117.34,80.82 117.42,80.87 117.48,80.93 119.15,80.93 119.25,80.94 119.33,81 120.02,81.69 123.87,81.69
AGND on IN3 (solid shape): 137.64,76.65 137.8,76.56 137.98,76.58 137.99,76.57 137.99,75.94 137.92,75.87 137.04,75.87 136.98,75.92 136.98,75.93 136.94,75.98 136.88,76.02 136.87,76.03 136.22,76.69 135.46,77.45 122.32,77.45 122.22,77.55 122.22,77.62 136.66,77.62
AGND on IN3 (solid shape): 126.92,78.59 136.98,78.59 137.18,78.39 137.18,78.31 137.05,78.18 122.02,78.18 121.67,78.53 117.53,78.53 117.22,78.84 117.22,79.43 117.34,79.56 118.41,79.56 119.04,80.19 120.14,80.19 120.7,80.75 123.74,80.75 123.75,80.69 123.76,80.64 123.78,80.59 123.81,80.55 123.84,80.51 123.88,80.47 123.92,80.44 123.97,80.42 124.02,80.4 124.07,80.39 124.13,80.39 124.18,80.4 124.23,80.42 124.28,80.44 124.32,80.47 124.36,80.51 124.4,80.55 124.42,80.59 124.44,80.64 124.45,80.69 124.46,80.75 124.45,80.8 124.44,80.85 124.42,80.9 124.4,80.95 124.36,80.99 124.32,81.03 124.28,81.06 124.23,81.08 124.18,81.1 124.13,81.1 124.07,81.1 124.02,81.1 123.97,81.08 123.92,81.06 123.88,81.03 123.84,80.99 123.81,80.95 123.78,80.9 123.76,80.85 123.75,80.8 123.74,80.75 120.7,80.75 121.33,81.38 124.13,81.38
AGND on IN3 (solid shape): 126.71,76.82 126.72,76.81 127.07,76.58 127.43,76.81 127.45,76.83 127.47,76.84 128.5,76.84 128.52,76.82 128.53,76.81 128.88,76.59 129.23,76.81 129.25,76.83 129.27,76.84 131.16,76.84 131.19,76.82 131.19,76.81 131.54,76.59 131.89,76.81 131.91,76.83 131.94,76.84 132.94,76.84 132.96,76.82 132.97,76.81 133.32,76.59 133.67,76.81 133.68,76.82 133.7,76.84 135.68,76.84 136.55,75.97 136.55,75.54 136.16,75.15 126.12,75.15 125.7,74.74 125.7,74.45 124.25,73 124.05,73 123.85,73.2 123.85,74.39 125.14,75.67 125.65,75.67 125.67,75.66 125.68,75.64 125.99,75.53 126.04,75.86 126.03,75.9 126.04,75.93 126.09,76.01 126.09,76.1 126.12,76.18 126.19,76.21 126.5,76.21 127,75.72 136.04,75.72 136.26,75.93 136.04,76.15 127.18,76.15 126.68,76.65 126.37,76.65 126.28,76.71 126.3,76.82 126.32,76.84 126.69,76.84
AGND on GND3 (solid shape): outline of 1516 points within 115.47,64.54 142.03,81.69
AGND on IN4 (solid shape): outline of 974 points within 115.47,64.54 141.63,81.69
AVDD_ADO on TOP (solid shape): 123.34,76.1 123.34,74.12 123.26,74.04 122.17,74.04 122.07,74.14 122.07,76.1 122.2,76.23 123.21,76.23
AVDD_ADO on IN1 (solid shape): 122.75,74.37 122.75,74.07 122.25,73.56 120.6,73.56 120.44,73.71 120.44,74.47 120.72,74.75 122.37,74.75
AVDD_ADO on IN3 (solid shape): 121.82,74.3 121.82,74.07 121.48,73.74 120.98,73.74 120.65,74.07 120.49,74.07 120.42,74.14 120.42,74.5 120.55,74.63 121.48,74.63
GND on TOP (solid shape): 53.41,55.12 51.66,55.12 51.66,55.97 51.93,56.24 53.41,56.24
GND on TOP (solid shape): 58.67,66.16 58.67,63.14 57.67,63.14 57.67,66.43 58.39,66.43
GND on TOP (solid shape): 54.12,38.76 54.12,38.38 54,38.25 51.08,38.25 50.95,38.38 50.95,38.76 51.08,38.89 54,38.89
GND on TOP (solid shape): 78.02,52.94 77.15,52.07 76.69,52.07 76.62,52.15 76.62,53.86 76.25,54.23 76.25,56.11 78.02,56.11
GND on TOP (solid shape): 152.17,73.69 152.17,72.54 151.91,72.29 151.28,72.29 151.15,72.42 151.15,73.56 151.41,73.81 152.04,73.81
GND on TOP (solid shape): 43.18,63.32 43.18,62.83 43.14,62.79 41.53,62.79 41.41,62.91 41.41,63.35 41.46,63.4 43.1,63.4
GND on TOP (solid shape): 113.41,68.96 116.1,68.96 116.33,68.73 116.33,68.54 112.87,68.54 112.87,69.06 112.93,69.11 113.26,69.11
GND on TOP (solid shape): 86.1,70.21 86.1,69.17 85.95,69.01 85.75,69.01 85.59,69.17 84.99,69.17 84.89,69.27 84.89,70.28 84.66,70.51 83.74,70.51 83.61,70.64 83.61,71.4 83.74,71.53 84.78,71.53
GND on TOP (solid shape): 50.21,56.99 49.76,56.53 49.76,55.74 50.25,55.25 50.26,55.17 50.19,55.12 50,55.12 49.07,56.05 49.07,59.4 49.08,59.41 50.21,59.41
GND on TOP (solid shape): 52.61,77.78 52.61,76.36 52.45,76.12 52.58,75.86 52.62,75.84 52.62,73.19 51.8,73.19 51.38,73.6 51.38,77.73 51.55,77.89 52.5,77.89
GND on TOP (solid shape): 65.69,47.37 66.04,47.37 66.04,46.48 65.99,46.41 65.91,46.43 65.84,46.5 64.44,46.5 64.44,46.62 63.55,46.62 63.55,47.46 63.13,47.46 62.81,47.79 62.78,47.95 62.92,48.05 65.69,48.05
GND on TOP (solid shape): 104.39,77.23 104.39,75.81 103.1,74.52 102.1,74.52 101.77,74.86 100.76,74.86 100.64,74.91 100.61,75.03 100.61,75.06 100.61,75.36 100.76,75.52 101.14,75.52 101.24,75.41 101.98,75.41 102.13,75.57 102.13,77.58 102.31,77.76 103.85,77.76
GND on TOP (solid shape): 118.17,55.88 118.34,55.91 118.43,55.77 118.43,54.76 118.39,54.66 118.3,54.61 118.23,54.59 118.17,54.56 118.15,54.54 117.4,54.54 117.25,54.69 117.25,55.15 117.32,55.22 117.95,55.22 118.03,55.3 118.03,55.74
GND on TOP (solid shape): 88.44,57.93 88.54,58.07 88.7,58.04 88.9,57.85 88.9,57.57 88.9,57.51 89,57.41 89.71,57.41 89.78,57.33 89.78,56.9 89.77,56.89 88.4,56.89 88.3,56.99 88.26,57.16 88.41,57.25 88.44,57.25
GND on TOP (solid shape): 49.58,66.93 49.67,67.07 49.84,67.04 50.21,66.66 50.21,62.85 49.14,62.85 49.01,62.98 49.01,63.84 49.63,63.84 49.63,64.4 48.97,64.4 48.97,64.03 48.93,63.99 48.14,63.99 48.13,63.99 48.13,64.51 48.89,65.27 48.89,66.64 49.58,66.64
GND on TOP (solid shape): 121.22,84.92 128.04,84.92 128.04,86.42 128.04,86.42 157.01,86.42 157.01,86.42 157.01,84.92 164.83,84.92 164.83,86.42 164.83,86.42 166.52,86.42 166.52,84.35 165.88,83.72 162.33,83.72 161.95,84.1 156.74,84.1 155.7,85.14 155.7,85.4 155.04,86.06 154.12,86.06 153.46,85.4 153.46,85.24 152.93,85.24 152.8,85.37 150.14,85.37 150.01,85.24 150.01,78.77 149.88,78.64 147.85,78.64 147.47,79.02 147.47,81.94 146.76,82.65 142.82,82.65 140.83,80.66 137.36,80.66 133.44,84.58 128.55,84.58 128.55,84.41 120.13,84.41 119.96,84.58 119.96,86.42 120.24,86.42 120.24,87.02 121.22,87.02
GND on TOP (solid shape): outline of 84 points within 27.91,49.2 42.42,63.53
GND on TOP (solid shape): 115.03,55.41 116.83,55.41 116.83,54.52 117.11,54.24 117.14,54.08 117,53.98 116.53,53.98 116.41,54.05 116.39,54.18 116.2,54.66 115.7,54.58 115.65,54.56 115.59,54.58 115.1,54.63 114.92,54.18 114.89,54.04 114.77,53.98 114.71,53.98 114.64,54.03 114.65,54.11 114.7,54.16 114.7,54.5 114.35,54.86 114.35,55.41 114.66,55.41 114.71,55.46 114.98,55.46
GND on TOP (solid shape): outline of 114 points within 74.91,60.35 86.28,69.41
GND on TOP (solid shape): 60.37,64.86 60.37,64.14 60.37,64.05 60.51,63.91 61.5,63.91 61.5,63.91 61.69,63.72 61.69,61.74 60.78,61.74 60.78,60.21 60.78,60.21 60.78,60.06 60.73,60.06 60.62,60.03 60.51,59.96 60.48,59.95 60.45,59.96 59.76,59.67 60.43,59.36 60.47,59.37 60.5,59.36 61.08,59.38 61.05,59.95 61.04,59.97 61.04,60.04 61.08,60.08 61.29,60.08 61.39,59.98 61.39,58.56 61.67,58.28 61.67,58.18 61.59,58.05 61.43,58.05 60.8,57.71 61.43,57.37 61.59,57.37 61.67,57.24 61.67,56.27 61.57,56.13 61.41,56.16 59.62,57.94 59.62,61.03 59.55,61.1 59.55,61.19 59.38,61.36 57.85,61.36 57.76,61.46 57.76,62.46 58.95,62.46 59.49,62.99 59.49,64.99 60.25,64.99
GND on TOP (solid shape): 92.49,64.52 93.91,64.52 94.23,64.19 94.26,64.03 94.12,63.93 91.91,63.93 91.04,63.93 90.9,64.03 90.92,64.19 90.62,64.87 90.32,64.19 90.36,64.05 90.25,63.94 90.23,63.93 89.27,63.93 89.23,63.89 89.15,63.89 89.15,63.08 89.25,63.08 89.27,63.07 90.94,63.07 90.99,63.12 91.91,63.12 94.12,63.12 94.26,63.03 94.23,62.86 93.79,62.42 93.79,62.21 93.7,62.07 93.53,62.1 93.43,62.21 87.77,62.21 87.77,64.11 87.83,64.17 87.83,65.95 87.88,66 88.39,66 88.78,65.61 88.78,64.95 90.33,64.95 90.33,65.09 90.86,65.62 90.86,65.79 90.89,65.86 91.18,65.97 91.26,66.18 91.29,66.27 91.38,66.33 91.45,66.35 91.51,66.4 91.74,66.52 91.7,66.79 91.7,68.72 91.7,68.73 92.49,68.73
GND on TOP (solid shape): outline of 93 points within 54.04,69.28 60.42,72.99
GND on TOP (solid shape): outline of 584 points within 39.9,35.28 90.75,61.09
GND on TOP (solid shape): outline of 1382 points within 60.55,51.7 109.74,87.42
GND on TOP (solid shape): outline of 5320 points within 0.51,0.51 175.29,86.42
GND on BOTTOM (solid shape): 68.43,85.41 65.77,85.41 65.77,85.92 68.43,85.92
GND on BOTTOM (solid shape): 90.95,73.69 90.95,72.54 89.24,72.54 89.09,72.7 89.09,73.81 90.83,73.81
GND on BOTTOM (solid shape): 82.47,53.15 82.53,53.09 82.53,52.71 80.07,52.71 80.07,53.17 80.08,53.18 80.08,54.38 82.47,54.38
GND on BOTTOM (solid shape): 119.69,74.99 119.69,70.6 115.31,70.6 115.31,74.99 115.31,75 119.68,75
GND on BOTTOM (solid shape): 28.48,20.88 28.47,20.88 28.47,18.16 28.39,18.08 27.87,18.08 27.8,18.15 27.8,21.62 28.48,21.62
GND on BOTTOM (solid shape): 116.17,59.92 116.17,58.6 116.06,58.49 116.06,57.53 115.9,57.37 115.76,57.37 115.68,57.44 115.68,60.03 116.06,60.03
GND on BOTTOM (solid shape): 85.7,68.61 85.7,68 85.04,67.34 85.04,65.84 84.99,65.79 84.78,65.79 84.73,65.84 84.73,67.49 85.01,67.77 85.01,68.56 85.14,68.68 85.62,68.68
GND on BOTTOM (solid shape): 108.18,45.56 108.24,45.5 108.63,45.5 108.63,42.39 105.33,42.39 105.18,42.55 105.18,44.55 105.36,44.73 107.59,44.73 107.69,44.83 107.69,45.57 108.18,45.57
GND on BOTTOM (solid shape): 84.22,60.48 84.22,58.62 85.04,57.81 85.04,57.08 84.96,57 84.1,57 83.92,57.18 83.92,60.48 83.94,60.5 84.2,60.5
GND on BOTTOM (solid shape): 20.52,61.89 20.52,60.42 21.49,59.45 21.49,56.29 21.36,56.16 20.72,56.16 20.6,56.29 20.6,56.95 20.6,59.7 19.94,60.36 19.94,61.98 20.43,61.98
GND on BOTTOM (solid shape): 86.1,50.17 85.95,50.01 85.06,50.01 84.93,50.14 84.93,51.4 84.77,51.56 84.78,51.58 84.78,52.52 84.64,52.65 84.64,53.06 84.76,53.18 84.76,53.3 84.87,53.42 86.1,53.42
GND on BOTTOM (solid shape): 81.78,62.41 81.78,62.26 81.73,62.21 80.69,62.21 78.48,60 75.89,60 75.82,60.07 75.82,60.89 75.89,60.96 78.76,60.96 80.26,62.46 81.73,62.46
GND on BOTTOM (solid shape): 82.7,44.48 83.59,44.48 83.71,44.36 83.71,41.77 83.74,41.74 83.74,40.95 83.61,40.82 81.49,40.82 81.49,39.12 82.33,39.12 82.33,38.41 81.53,38.41 80.46,39.48 80.46,44.65 80.82,45 82.18,45
GND on BOTTOM (solid shape): 94.3,61.41 94.39,61.55 94.56,61.51 94.59,61.48 94.59,55.3 93.39,55.3 93.39,58.62 94.3,58.62
GND on BOTTOM (solid shape): 89.25,60.78 90.32,60.78 90.37,60.73 90.37,59.36 90.24,59.23 89.56,59.23 89.25,59.54 89.25,60.15 88.01,61.39 87.19,61.39 87.14,61.44 87.14,61.65 87.19,61.7 88.34,61.7
GND on BOTTOM (solid shape): 83.82,60.48 83.82,57.08 84.02,56.87 84.22,56.87 84.35,56.75 84.35,54.71 84.27,54.64 83.41,54.64 83.36,54.69 83.36,58.75 83.54,58.93 83.54,60.48 83.56,60.5 83.79,60.5
GND on BOTTOM (solid shape): 94.48,67.5 94.07,67.08 92.96,67.08 92.82,67.18 92.85,67.34 92.91,67.4 92.91,67.46 92.92,67.46 92.92,68.33 94.48,68.33
GND on BOTTOM (solid shape): 51.81,73.62 52.47,73.62 52.47,72.76 52.35,72.63 52.35,72.48 51.84,72.48 51.34,72.98 51.34,74.07 51.48,74.21 51.48,74.65 51.48,74.68 51.48,75.01 51.48,75.24 51.37,75.24 51.36,75.24 51.36,75.4 51.81,75.4
GND on BOTTOM (solid shape): 77.29,73.28 77.29,72.32 77.49,72.11 78.56,72.11 79.09,71.58 79.09,70.31 78.99,70.21 75.92,70.21 75.74,70.38 75.74,70.97 75.59,71.12 74.49,71.12 73.5,72.11 73.5,73.28 73.61,73.38 77.19,73.38
GND on BOTTOM (solid shape): 111.78,77.88 111.78,74.45 112.04,74.19 112.29,74.19 112.48,74 112.48,73.88 112.29,73.69 111.1,73.69 110.87,73.92 110.87,74.3 110.69,74.47 110.05,74.47 109.88,74.65 109.88,76.48 110,76.61 110.51,76.61 110.77,76.86 110.77,77.88 110.89,78 111.66,78
GND on BOTTOM (solid shape): 91.82,64.26 91.82,63.55 91.74,63.48 89.13,63.48 88.67,63.02 87.24,63.02 87.17,63.09 87.17,63.25 87.22,63.3 87.27,63.29 87.33,63.3 88.41,63.3 89.46,64.34 91.74,64.34
GND on BOTTOM (solid shape): 91.08,50.21 91.08,48.49 90.8,48.21 90.8,47.08 90.41,46.69 89.52,46.69 89.36,46.84 89.36,50.37 89.4,50.47 89.5,50.52 89.58,50.54 89.65,50.58 89.67,50.59 90.7,50.59
GND on BOTTOM (solid shape): 87.75,60.58 87.75,60.54 88.06,60.24 88.06,60.08 87.97,60.08 87.95,60.08 87.85,60.1 87.75,60.08 87.75,60.05 87.7,60 87.42,60 87.39,60.03 87.38,60.03 87.16,60.25 87.16,60.26 87.14,60.28 87.14,60.5 87.04,60.61 86.81,60.61 86.76,60.66 86.76,60.83 86.79,60.86 87.47,60.86
GND on BOTTOM (solid shape): 64.06,72.7 64.06,72.16 64.13,72.09 65.12,72.09 65.15,72.06 65.15,71.17 65.12,71.15 65.04,71.15 64.77,71.15 64.63,71.01 64.63,69.64 64.38,69.4 63.38,69.4 63.31,69.47 63.31,69.47 63.24,69.54 63.24,70.04 63.38,70.18 63.38,72.58 63.62,72.82 63.93,72.82
GND on BOTTOM (solid shape): 19.92,43.07 19.9,43.07 19.9,42.36 20.66,42.36 20.66,42.51 21.08,42.51 21.08,42.33 22.01,42.33 22.01,41.6 21.83,41.42 19.14,41.42 18.88,41.68 18.85,41.84 18.99,41.94 19.54,41.94 19.54,42.7 19.34,42.7 19.34,43.43 19.92,43.43
GND on BOTTOM (solid shape): 80.62,64.06 81.73,64.06 81.78,64.01 81.78,63.48 81.73,63.43 79.96,63.43 79.88,63.35 75.54,63.35 75.38,63.2 75.38,62.41 75.26,62.28 74.06,62.28 73.91,62.43 73.91,63.55 73.66,63.81 72.39,63.81 71.98,63.4 71.42,63.4 71.32,63.5 71.32,63.86 71.37,63.91 71.8,63.91 72.16,64.26 73.91,64.26 74.19,64.54 74.19,65.86 74.37,66.04 78.64,66.04
GND on BOTTOM (solid shape): 59.74,60.37 59.8,60.35 60.83,60.35 60.88,60.35 61.36,59.87 61.72,59.87 61.74,59.84 61.74,59.51 61.72,59.49 61.29,59.49 61.16,59.62 61.16,59.77 60.91,60.02 59.61,60.02 59.49,60.14 59.49,60.26 59.51,60.27 59.55,60.31 59.59,60.35 59.61,60.38 59.73,60.38
GND on BOTTOM (solid shape): 78.81,56.68 78.97,56.71 79.07,56.57 79.07,54.71 77.96,54.71 77.96,54.43 77.92,54.4 77.92,53.18 77.96,53.14 77.96,52.71 74.35,52.71 73.96,53.1 73.96,54.72 74.22,54.72 74.33,54.61 75.68,54.61 75.79,54.72 75.92,54.72 75.92,55.62 76.01,55.7 77.83,55.7
GND on BOTTOM (solid shape): 84.45,73.28 84.45,72.32 84.63,72.14 85.52,72.14 85.95,71.71 85.95,70.33 85.85,70.23 84.4,70.23 83.61,69.45 83.61,67.62 83.82,67.41 83.82,65.86 83.79,65.84 83.63,65.84 83.56,65.87 83.53,65.94 83.53,65.99 83.51,66.04 83.51,67.16 83.18,67.49 83.18,71.93 82.62,72.49 82.62,73.36 82.67,73.41 84.32,73.41
GND on BOTTOM (solid shape): 117.68,57.15 117.9,56.84 118.28,56.85 118.3,56.86 120.23,56.86 120.5,56.58 120.5,55.32 120.4,55.22 117.81,55.22 116.77,56.25 116.74,56.42 116.88,56.52 116.98,56.52 116.98,57.21 117.67,57.21
GND on BOTTOM (solid shape): 86.64,61.24 86.64,60.2 87.23,59.61 87.67,59.61 87.69,59.59 87.78,59.55 87.89,59.54 88.01,59.5 88.06,59.39 88.06,59.3 89.16,58.2 89.2,58.11 89.18,58.01 89.18,57.15 89.13,57.1 88.41,57.1 88.36,57.15 88.36,58.32 88.01,58.68 87.63,58.68 86.33,59.97 86.33,61.24 86.38,61.29 86.59,61.29
GND on BOTTOM (solid shape): 32.52,7.35 32.66,7.26 32.62,7.09 32.52,6.99 31.33,6.99 31.09,6.75 31.09,6.52 20.96,6.52 20.89,6.57 20.91,6.65 20.93,6.67 20.93,7.2 20.9,7.22 20.89,7.31 20.96,7.35
GND on BOTTOM (solid shape): 82.03,50.42 82.15,50.44 82.25,50.37 82.52,50.17 82.84,50.25 82.89,50.26 82.94,50.24 82.99,50.2 83.06,50.09 83.02,49.97 82.93,49.87 82.93,48.21 81.25,48.21 81.15,48.31 81.15,50.32 81.25,50.42
GND on BOTTOM (solid shape): 50.08,56.31 50.11,56.28 50.15,56.17 50.14,56.11 50.14,56.09 50.14,55.27 49.7,54.84 49.7,54.18 49.78,54.1 50.54,54.1 50.57,54.13 50.57,54.56 50.59,54.59 50.85,54.59 50.87,54.56 50.87,53.54 51,53.42 51.58,53.42 51.58,52.48 51.51,52.4 50.36,52.4 50.31,52.45 50.31,53.62 50.19,53.75 49.47,53.75 49.41,53.8 48.74,53.8 48.74,53.98 49.32,53.98 49.32,55.42 49.65,55.75 49.65,56.06 49.65,56.08 49.89,56.31
GND on BOTTOM (solid shape): 90.22,56.87 90.36,56.78 90.32,56.61 90.01,56.3 90.01,55.23 90.23,55.02 91.92,55.02 91.92,54.22 92.11,54.03 93.21,54.03 93.21,51.78 93.1,51.67 91.03,51.67 90.95,51.59 90.95,51.21 90.76,51.01 89.67,51.01 89.65,51.03 89.58,51.06 89.5,51.08 89.4,51.13 89.36,51.23 89.36,52.8 89.35,52.8 89.35,53 89.76,53.41 89.76,55 89.72,55.04 89.72,55.6 89.74,55.62 89.74,56.87
GND on BOTTOM (solid shape): 55.36,56.69 55.45,56.66 55.51,56.61 55.58,56.58 55.62,56.57 55.62,56.37 55.71,56.33 55.76,56.29 55.8,56.22 55.88,56.14 55.88,54.72 55.93,54.67 55.93,54.6 56.02,54.51 56.02,54.32 55.88,54.18 55.57,54.18 55.52,54.23 55.52,54.79 55.39,54.92 55.39,55.48 55.37,55.48 55.37,56.23 55.3,56.3 55.28,56.31 55.24,56.36 55.2,56.39 55.19,56.41 55.19,56.43 55.18,56.55 55.21,56.57 55.25,56.6 55.28,56.65
GND on BOTTOM (solid shape): 96.75,64.16 96.75,63.2 96.43,62.88 94.36,62.88 94.36,62.97 94.41,63.08 94.52,63.12 94.97,63.53 94.52,63.93 94.41,63.97 94.36,64.08 94.36,64.24 96.07,64.24 96.18,64.35 96.56,64.35
GND on BOTTOM (solid shape): 108.35,75.72 108.35,74.6 107.79,74.04 107.79,72.67 107.78,72.67 107.78,70.76 107.87,70.66 108.86,70.66 108.9,70.65 108.91,70.61 108.91,70.44 108.9,70.4 108.86,70.38 107.87,70.38 107.78,70.29 107.78,65.49 107.72,65.43 106.58,65.43 106.45,65.56 106.45,69.19 105.88,69.76 105.88,70.8 105.81,70.87 104.8,70.87 104.76,70.88 104.75,70.92 104.75,71.12 104.76,71.16 104.8,71.17 105.81,71.17 105.88,71.24 105.88,72.67 105.86,72.67 105.86,73.78 106.47,74.39 106.47,75.62 106.75,75.9 108.18,75.9
GND on BOTTOM (solid shape): 54.18,56.69 54.26,56.65 54.34,56.57 54.45,56.54 54.49,56.53 54.5,56.49 54.5,56.42 54.76,56.16 54.76,54.41 54.76,54.21 54.73,54.18 54.38,54.18 54.38,54.71 54.36,54.71 54.3,54.78 54.3,54.79 54.25,54.84 54.25,56.18 54.2,56.23 54.2,56.24 54.17,56.27 54.12,56.34 54.07,56.39 54.06,56.41 54.06,56.44 54.05,56.5 53.99,56.56 54.03,56.61 54.07,56.63 54.1,56.66
GND on BOTTOM (solid shape): 93.87,45.16 94.38,45.16 94.38,45.17 94.51,45.17 95.15,44.53 95.15,44.5 95.16,44.38 95.23,44.28 95.26,44.2 95.18,44.15 95.17,44.15 94.66,44.15 94.42,44.01 94.41,43.74 94.42,43.72 94.42,43.53 93.21,43.53 93.13,43.55 93.07,43.6 93.11,43.74 93.07,43.88 93.06,43.9 93.06,45.01 93.23,45.17 93.87,45.17
GND on BOTTOM (solid shape): 51.92,56.69 52,56.65 52.03,56.6 52.08,56.57 52.1,56.55 52.1,56.51 52.09,56.49 52.09,56.42 52.08,56.39 52.04,56.35 52,56.3 51.94,56.24 51.94,55.99 52,55.93 52,55.87 52.02,55.86 52.02,54.21 51.99,54.18 51.69,54.18 51.61,54.26 51.61,55.87 51.48,56 51.48,56.27 51.5,56.29 51.56,56.33 51.63,56.42 51.64,56.5 51.64,56.53 51.65,56.56 51.69,56.58 51.77,56.6 51.83,56.66
GND on BOTTOM (solid shape): 53.1,56.69 53.18,56.66 53.25,56.61 53.32,56.58 53.36,56.57 53.36,56.43 53.23,56.42 53.22,56.39 53.17,56.35 53.13,56.31 53.08,56.25 53.08,54.72 53.11,54.7 53.11,54.23 53.08,54.21 52.75,54.21 52.7,54.26 52.7,55.88 52.6,55.98 52.6,56.19 52.62,56.23 52.66,56.3 52.73,56.34 52.76,56.35 52.8,56.4 52.8,56.49 52.82,56.53 52.85,56.54 52.94,56.57 52.97,56.59 53,56.62 53.02,56.65
GND on BOTTOM (solid shape): 79.12,50.24 79.12,48.36 78.98,48.21 78.35,48.21 78.2,48.06 76.92,48.06 76.54,48.44 74.7,48.44 74.57,48.57 74.57,49.66 77.24,49.66 77.24,48.95 77.24,48.92 77.24,48.86 77.26,48.8 77.28,48.74 77.31,48.69 77.35,48.64 77.39,48.6 77.44,48.57 77.49,48.54 77.55,48.51 77.61,48.5 77.67,48.49 77.73,48.49 77.78,48.5 77.84,48.51 77.9,48.54 77.95,48.57 78,48.6 78.04,48.64 78.08,48.69 78.11,48.74 78.13,48.8 78.15,48.86 78.15,48.92 78.15,48.95 78.15,49.66 78.15,49.69 78.15,49.75 78.13,49.81 78.11,49.86 78.08,49.91 78.04,49.96 78,50 77.95,50.04 77.9,50.07 77.84,50.09 77.78,50.11 77.73,50.12 77.67,50.12 77.61,50.11 77.55,50.09 77.49,50.07 77.44,50.04 77.39,50 77.35,49.96 77.31,49.91 77.28,49.86 77.26,49.81 77.24,49.75 77.24,49.69 77.24,49.66 74.57,49.66 74.57,50.29 74.7,50.42 78.94,50.42
GND on BOTTOM (solid shape): 94.51,76.05 94.51,72.54 94.32,72.35 93.89,72.35 93.44,71.91 93.44,71.17 93.32,71.05 91.82,71.05 91.56,70.79 91.56,69.11 90.95,68.51 90.95,68.18 90.93,68.15 90.93,68.09 90.92,68.07 90.85,68.07 90.84,68.06 89.62,68.06 87.83,66.27 87.83,65.41 87.44,65.03 86.79,65.03 86.74,65.08 86.74,65.2 86.81,65.28 87.04,65.28 87.12,65.36 87.12,65.47 86.91,65.8 86.62,65.53 86.52,65.43 86.46,65.43 86.36,65.53 86.36,66.33 86.96,66.93 87.96,66.93 89.13,68.1 89.13,69.11 89.23,69.22 90.06,69.22 90.1,69.24 90.13,69.27 90.61,69.27 90.87,69.53 90.89,69.54 90.91,69.56 91,69.65 91,71.05 91.97,72.01 92.53,72.01 93.14,72.62 93.14,75.69 93.54,76.1 94.46,76.1
GND on BOTTOM (solid shape): 59.44,64.58 59.47,64.54 59.51,64.51 59.52,64.47 59.57,64.39 59.67,64.35 59.71,64.34 59.75,64.33 59.79,64.3 59.84,64.22 59.87,64.11 59.97,64.11 59.99,64.09 61.64,64.09 61.69,64.03 61.69,63.81 61.67,63.78 61.34,63.78 61.29,63.83 59.81,63.83 59.78,63.86 59.65,63.86 59.62,63.87 59.6,63.91 59.52,64.06 59.28,64.13 59.24,64.19 59.22,64.27 59.16,64.34 59.13,64.42 59.18,64.5 59.22,64.53 59.25,64.58 59.27,64.61
GND on BOTTOM (solid shape): 60.02,58.93 61.09,58.93 61.29,58.74 63.07,58.74 63.28,58.52 63.28,57.98 63.29,57.96 63.29,57.3 63.16,57.17 62.98,57.17 62.69,57.45 62.69,57.8 62.46,58.42 62.22,57.8 62.22,57.26 62.59,56.88 62.59,56.67 62.53,56.61 62.15,56.61 62.15,55.73 62.05,55.63 61.62,55.63 61.54,55.7 61.54,57.47 61.53,57.96 61.06,58.09 61.05,58.09 60.92,58.09 60.39,58.62 59.91,58.62 59.51,59.02 59.51,59.13 59.56,59.18 59.61,59.24 59.71,59.24
GND on BOTTOM (solid shape): 99.72,63.12 99.86,63.02 99.82,62.86 99.82,62.85 99.82,61.84 99.98,61.67 99.98,61.09 100.8,61.09 101.8,61.09 101.94,60.99 101.9,60.83 101.65,60.57 101.65,60.23 101.86,60.03 101.87,59.94 101.8,59.89 100.85,59.89 100.62,59.67 100.62,58.07 100.46,57.91 100.02,57.91 100.01,57.9 100.01,56.35 99.52,56.35 98.98,55.81 98.89,55.81 98.89,54.99 99.62,54.99 99.69,54.92 99.69,54.19 99.08,53.58 99.08,51.74 98.99,51.6 98.82,51.63 98.82,51.64 98.13,51.64 97.96,51.47 97.96,51.32 97.81,51.16 96.75,51.16 96.67,51.25 96.67,53.14 97.03,53.49 96.67,53.85 96.67,54.53 97.03,54.89 96.67,55.25 96.67,62.23 96.76,62.37 96.93,62.33 97.04,62.22 97.16,62.22 97.16,61.19 97.19,61.19 97.19,60.27 98.84,60.27 98.84,61.09 98.82,61.09 98.82,62.71 99.03,62.71 99.44,63.12
GND on BOTTOM (solid shape): 43.51,68.4 43.61,68.4 43.78,68.42 43.91,68.53 43.99,68.53 43.99,68.58 44.07,68.58 44.08,68.56 44.17,68.47 44.29,68.44 44.32,68.42 44.41,68.23 44.6,68.14 44.62,68.11 44.65,68 44.71,67.92 44.75,67.84 44.71,67.76 44.69,67.73 44.66,67.71 44.57,67.66 44.49,67.72 44.39,67.82 44.25,67.85 44.21,67.86 44.19,67.89 43.74,68 43.96,67.59 44,67.58 44.11,67.39 44.28,67.34 44.32,67.33 44.33,67.29 44.33,67.26 44.32,67.22 44.28,67.21 44.16,67.19 44.06,67.11 43.93,67.11 43.91,67.13 43.84,67.22 43.73,67.27 43.72,67.28 43.58,67.42 43.55,67.44 43.52,67.47 43.15,67.85 43.15,68.56 43.2,68.61 43.3,68.61
GND on BOTTOM (solid shape): 32.01,75.51 35.21,75.51 35.21,75.33 35.17,75.31 35.12,75.28 35.07,75.24 35.01,75.22 34.76,75.32 34.51,75.22 34.26,75.32 34.01,75.22 33.76,75.32 33.51,75.22 33.26,75.32 33.01,75.22 32.76,75.32 32.51,75.22 32.26,75.32 32.07,75.24 32.07,75.24 31.99,75.06 32.1,74.81 31.99,74.56 32.1,74.31 31.99,74.06 32.1,73.81 31.99,73.56 32.1,73.31 31.99,73.06 32.1,72.81 31.99,72.56 32.1,72.31 32.07,72.24 32.03,72.2 32.01,72.15 31.99,72.1 31.8,72.1 31.8,75.31 31.8,75.34 31.84,75.47 31.97,75.51
GND on BOTTOM (solid shape): 31.96,57.37 32.09,57.3 32.1,57.15 32.07,57.1 31.99,56.91 32.1,56.66 31.99,56.41 32.1,56.16 31.99,55.91 32.1,55.66 31.99,55.41 32.1,55.16 31.99,54.91 32.1,54.66 31.99,54.41 32.07,54.23 32.07,54.22 32.26,54.14 32.51,54.25 32.76,54.14 33.01,54.25 33.26,54.14 33.51,54.25 33.76,54.14 34.01,54.25 34.26,54.14 34.51,54.25 34.76,54.14 35.01,54.25 35.07,54.22 35.12,54.19 35.17,54.16 35.21,54.14 35.21,53.95 32.01,53.95 31.97,53.95 31.84,54 31.8,54.12 31.8,54.16 31.8,57.21
GND on BOTTOM (solid shape): 43.93,61.22 44.01,61.26 44.09,61.23 44.17,61.17 44.26,61.14 44.33,61.11 44.36,61.04 44.36,61.01 44.35,60.97 44.3,60.95 44.14,60.92 44.05,60.79 44.01,60.73 43.95,60.71 43.76,60.35 44.17,60.43 44.2,60.48 44.26,60.5 44.44,60.58 44.49,60.77 44.51,60.81 44.55,60.83 44.56,60.82 44.61,60.8 44.64,60.74 44.72,60.59 44.87,60.54 44.91,60.52 44.92,60.49 44.92,60.48 44.91,60.44 44.87,60.43 44.72,60.37 44.64,60.23 44.61,60.17 44.43,60.08 44.33,59.89 44.27,59.86 44.09,59.7 44.16,59.46 44.19,59.38 44.14,59.3 44.09,59.26 44.06,59.2 44.04,59.16 43.89,59.21 43.84,59.26 43.8,59.29 43.79,59.35 43.8,59.41 43.85,59.44 43.89,59.49 43.96,59.53 43.96,59.68 43.93,59.75 43.88,59.79 43.86,59.82 43.85,59.85 43.84,59.88 43.83,59.93 43.72,60.01 43.66,60.01 43.52,60.08 43.48,60.24 43.48,60.26 43.48,60.71 43.48,60.73 43.51,60.87 43.63,60.95 43.68,60.96 43.85,61.14 43.88,61.17
GND on BOTTOM (solid shape): outline of 103 points within 52.63,70.08 62.77,75.4
GND on BOTTOM (solid shape): outline of 109 points within 43.51,53.29 48.33,57.99
GND on BOTTOM (solid shape): outline of 294 points within 58.96,60.42 67.84,69.45
GND on BOTTOM (solid shape): outline of 134 points within 49.59,60.66 53.73,66.7
GND on BOTTOM (solid shape): outline of 3120 points within 44.38,56.55 52.52,71.75
GND on BOTTOM (solid shape): outline of 3997 points within 50.2,55.88 59.81,71.44
GND on BOTTOM (solid shape): outline of 8779 points within 0.51,0.51 175.29,87.42
GND on IN1 (solid shape): 63.57,73.64 63.57,73.08 63.45,72.95 63.45,72.75 63.09,72.39 63.09,71.65 63.06,71.63 62.18,71.63 62.13,71.68 62.13,72.37 62.89,73.13 62.89,73.64 62.94,73.69 63.52,73.69
GND on IN1 (solid shape): 110.79,56.73 110.87,56.75 110.92,56.68 110.92,55.89 112.36,54.45 112.38,54.39 112.36,54.34 112.33,54.31 111.91,54.31 110.65,55.58 110.65,56.59
GND on IN1 (solid shape): 100.76,52.54 100.85,52.68 101.02,52.65 101.4,52.26 105.52,52.26 105.66,52.17 105.63,52 104.12,50.5 100.85,50.5 100.76,50.59
GND on IN1 (solid shape): 87.65,76.03 87.77,76.08 87.88,76.01 88.04,75.88 88.25,75.85 88.35,75.74 88.35,75.59 87.16,74.4 86.34,74.4 85.63,73.69 82.88,73.69 82.74,73.78 82.77,73.95 84.26,75.44 87.05,75.44
GND on IN1 (solid shape): 54.57,38.58 60.61,38.58 60.75,38.51 60.74,38.35 60.7,38.25 52.73,38.25 52.72,38.27 51.36,38.27 51.23,38.13 51.2,38.13 50.31,37.24 50.31,36.6 50.21,36.5 42.5,36.5 40.86,38.15 40.83,38.31 40.97,38.41 50.76,38.41 51.14,38.79 54.37,38.79
GND on IN1 (solid shape): 46.08,84.65 46.22,84.56 46.19,84.39 45.83,84.04 45.83,83.36 46.13,83.05 46.17,82.89 46.03,82.79 29.87,82.79 29.73,82.89 29.77,83.05 30.07,83.36 30.07,84.04 29.71,84.39 29.68,84.56 29.82,84.65
GND on IN1 (solid shape): 127.06,56.53 126.92,56.39 124.25,56.39 124.17,56.47 124.17,56.83 125.39,58.05 125.83,58.05 125.83,58 125.85,57.94 125.87,57.89 125.9,57.84 125.93,57.79 125.97,57.75 126.02,57.72 126.07,57.69 126.12,57.67 126.18,57.66 126.23,57.66 126.29,57.66 126.35,57.67 126.4,57.69 126.45,57.72 126.5,57.75 126.54,57.79 126.57,57.84 126.6,57.89 126.62,57.94 126.64,58 126.64,58.05 126.64,58.11 126.63,58.16 126.61,58.22 126.59,58.27 126.56,58.32 126.52,58.36 126.47,58.4 126.43,58.43 126.37,58.45 126.32,58.46 126.26,58.47 126.21,58.47 126.15,58.46 126.1,58.45 126.04,58.43 126,58.4 125.95,58.36 125.91,58.32 125.88,58.27 125.86,58.22 125.84,58.16 125.83,58.11 125.83,58.05 125.39,58.05 126.92,59.58 126.92,66.22 127.06,66.22
GND on IN1 (solid shape): 110.2,55.98 110.25,55.96 110.28,55.91 110.28,55.42 111.76,53.94 112.33,53.94 112.36,53.92 112.44,53.84 111.64,53.04 110.42,53.04 110.4,53.04 107.71,53.04 107.57,53.13 107.6,53.3 109.32,55.02 109.49,55.05 109.58,54.91 109.58,53.76 109.67,53.67 109.68,53.65 110.13,53.48 110.06,53.95 110.02,53.97 110.02,55.83 110.06,55.94 110.17,55.98
GND on IN1 (solid shape): outline of 93 points within 59.28,69.93 63.09,72.32
GND on IN1 (solid shape): 93.51,55.7 93.57,55.73 93.63,55.7 93.67,55.65 96.01,55.65 96.47,55.19 96.33,54.78 96.68,54.53 96.68,53.85 96.31,53.49 96.68,53.14 96.68,51.44 94.24,49 90.47,49 90.33,49.09 90.36,49.26 91.64,50.54 91.64,50.73 91.68,50.73 91.78,50.77 91.87,50.84 91.94,50.87 92.02,50.84 92.71,51.13 92.02,51.42 91.94,51.39 91.87,51.42 91.78,51.49 91.68,51.53 91.64,51.54 91.64,54.85 92.6,54.85 93.4,55.65 93.47,55.65
GND on IN1 (solid shape): 94,37.79 94.11,37.75 94.15,37.65 94.21,37.52 94.33,37.45 94.39,37.43 94.39,37.21 94.19,37.02 93.97,37.02 93.63,36.67 93.63,36.52 93.56,36.44 93.53,36.44 93.41,36.4 93.34,36.3 93.23,36.21 93.09,36.25 92.86,36.48 92.82,36.63 92.93,36.73 92.99,37.16 92.67,36.87 92.69,36.82 92.6,36.73 92.44,36.9 90.66,36.9 90.52,37.03 90.52,37.41 90.57,37.45 90.65,37.5 90.74,37.48 90.87,37.46 90.99,37.52 91.09,37.55 91.19,37.52 91.35,37.46 91.5,37.53 91.61,37.57 91.72,37.52 91.97,37.45 92.12,37.65 92.17,37.75 92.27,37.79
GND on IN1 (solid shape): 102.89,72.59 102.89,60.71 102.82,60.58 102.66,60.58 102.13,60.46 102.2,59.91 102.23,59.85 102.2,59.79 102.16,59.75 102.1,59.73 102.05,59.75 101.97,59.81 101.88,59.85 101.79,59.93 101.78,60.05 101.68,60.38 101.34,60.37 101.15,60.43 100.97,60.35 100.97,60.32 100.86,60.21 100.86,60.06 100.97,59.95 100.97,59.84 100.87,59.74 100.67,59.74 100.53,59.88 100.53,60.46 101.44,61.38 101.51,61.41 101.58,61.38 101.63,61.35 101.76,61.29 101.9,61.31 101.92,61.32 102.01,61.32 102.03,61.31 102.16,61.29 102.29,61.34 102.44,61.55 102.32,61.79 102.28,61.81 102.28,62.7 102.37,62.79 102.37,63.1 102.16,63.31 101.85,63.31 101.83,63.29 100.75,63.29 100.63,63.4 100.63,67.69 100.48,67.84 100.17,67.84 100.07,67.95 100.07,70.43 102.29,72.65 102.84,72.65
GND on IN1 (solid shape): outline of 193 points within 69.99,55.58 77.65,68.38
GND on IN1 (solid shape): outline of 236 points within 79.92,52.78 88.34,56.92
GND on IN1 (solid shape): outline of 254 points within 46.61,50.04 61.79,61.37
GND on IN1 (solid shape): outline of 313 points within 25.6,34.04 42.64,44.22
GND on IN1 (solid shape): outline of 82 points within 75.84,58.75 90.43,62.64
GND on IN1 (solid shape): outline of 373 points within 126.08,67.59 148.49,73
GND on IN1 (solid shape): outline of 376 points within 90.95,58.73 97.16,75.67
GND on IN1 (solid shape): outline of 552 points within 100.91,41.2 121.38,50.57
GND on IN1 (solid shape): outline of 953 points within 111.53,50.55 125.98,60.58
GND on IN1 (solid shape): outline of 1053 points within 74.95,62.21 91.49,69.32
GND on IN1 (solid shape): outline of 1161 points within 24.71,41.84 51.38,82.11
GND on IN1 (solid shape): outline of 1946 points within 100.69,53.61 125.26,79.6
GND on IN1 (solid shape): outline of 2708 points within 46.95,71.73 166.27,87.42
GND on IN1 (solid shape): outline of 3282 points within 0.51,0.51 175.29,86.42
GND on GND1 (solid shape): outline of 51158 points within 0.51,0.51 175.29,87.42
GND on IN2 (solid shape): 68.43,85.41 65.77,85.41 65.77,85.92 68.43,85.92
GND on IN2 (solid shape): 34.57,42.44 34.57,41.43 26.69,33.55 25.42,33.55 25.04,33.94 25.04,38.51 21.1,42.44 21.1,42.57 21.23,42.7 34.31,42.7
GND on IN2 (solid shape): 84.69,64.87 84.69,64.68 84.64,64.63 84.41,64.44 84.41,64.13 84.41,63.98 84.28,63.91 83.37,63.91 83.18,64.1 83.18,64.51 83.27,64.59 83.85,64.59 84.2,64.94 84.2,64.95 84.61,64.95
GND on IN2 (solid shape): 16.33,48.94 17.04,48.94 17.16,48.83 17.16,48.69 17.07,48.6 16.94,48.6 16.7,48.36 16.7,47.45 16.94,47.21 17.29,47.21 17.48,47.01 17.48,46.71 17.06,46.29 15.96,46.29 15.46,46.79 15.11,46.79 15.08,46.76 14.85,46.76 14.82,46.79 14.48,46.79 14.44,46.75 14.27,46.72 14.18,46.86 14.18,48.98 14.56,49.36 15.91,49.36
GND on IN2 (solid shape): 58.67,68.97 58.74,68.92 58.72,68.84 58.64,68.75 58.64,68.23 58.57,68.16 58.27,68.16 58.14,68.02 58.14,67.1 58.15,67.09 58.15,67.05 58.75,66.45 58.75,65.86 58.91,65.7 59.7,65.7 59.71,65.71 59.76,65.65 59.76,62.76 59.7,62.71 59.66,62.65 59.64,62.61 57.8,62.61 57.59,62.83 57.59,64.57 57.43,64.73 57.43,67.34 57.42,67.39 57.41,67.44 57.4,67.45 57.35,67.53 57.27,67.59 57.27,68.64 57.3,68.66 57.83,68.66 58.14,68.97
GND on IN2 (solid shape): outline of 151 points within 87.73,62.36 93.64,66.81
GND on IN2 (solid shape): 139.02,78.46 139.54,78.46 141.88,76.12 141.88,74.5 140.56,73.18 139.34,73.18 139.26,73.26 139.26,73.38 139.08,73.67 138.75,73.57 136.66,73.57 136.42,73.33 127.61,73.33 125.9,71.63 125.9,68.7 125.03,67.83 125.03,64.61 124.86,64.46 124.86,64.23 124.52,63.89 122.63,63.89 122.3,64.21 122.05,64.21 118.34,67.93 116.91,67.93 116.77,68.07 116.77,69.68 116.93,69.84 117.13,69.84 117.34,69.63 117.35,69.61 117.82,69.45 117.66,69.93 117.64,69.93 117.23,70.34 117.09,70.34 116.96,70.47 116.96,70.84 117.01,70.89 119.1,70.89 119.35,70.64 119.35,69.98 120.55,68.78 123.53,68.78 123.62,68.69 124.6,68.69 124.86,68.96 124.86,72.24 126.82,74.19 128.77,74.19 129.63,75.05 131.83,75.05 131.83,75.06 133.68,75.06 134.79,76.18 134.79,77.95 131.47,81.27 125.79,81.27 125.32,81.74 125.32,82.82 125.7,83.2 131.67,83.2 131.72,83.06 131.8,82.94 131.85,82.83 131.81,82.73 131.82,82.11 132.43,82.06 132.52,82.09 132.62,82.05 133.26,82.09 133.23,82.73 133.18,82.84 133.22,82.95 133.32,83.12 133.35,83.31 133.38,83.43 133.5,83.48 134,83.48
GND on IN2 (solid shape): outline of 486 points within 51.73,61.52 56.87,68.41
GND on IN2 (solid shape): outline of 559 points within 97.34,41.16 113.75,57.16
GND on IN2 (solid shape): outline of 995 points within 9.01,47.51 52.17,82.25
GND on IN2 (solid shape): outline of 1476 points within 13.61,0.51 175.29,75.41
GND on IN2 (solid shape): outline of 1756 points within 0.51,40.27 166.25,87.42
GND on SVCC2 (solid shape): outline of 84 points within 1.66,40.78 48.03,82.88
GND on SVCC2 (solid shape): outline of 647 points within 15.9,1.01 174.78,86.24
GND on SGND2 (solid shape): outline of 1223 points within 0.51,0.51 175.29,87.42
GND on IN3 (solid shape): 21.08,9.83 21.08,8.28 20.89,8.1 19.17,8.1 17.97,9.29 17.97,9.72 18.13,9.88 21.03,9.88
GND on IN3 (solid shape): 26.95,56.91 26.98,56.91 27.63,56.26 29.51,56.26 29.88,55.89 29.88,54.76 29.69,54.57 26.51,54.57 25.76,55.32 25.76,56.95 25.58,57.13 25.57,57.28 26.58,57.28
GND on IN3 (solid shape): 108.73,43.97 107.24,42.48 104.8,42.48 104.21,43.06 103.3,43.06 103.16,43.16 103.19,43.32 105.56,45.69 107.01,45.69
GND on IN3 (solid shape): 104.75,52.52 104.89,52.43 104.85,52.26 103.12,50.53 102.44,50.53 100.26,48.35 100.1,48.32 100,48.46 100,50.57 101.95,52.52
GND on IN3 (solid shape): 88.6,62.24 88.63,62.16 88.54,62.07 88.35,62.26 87.05,62.26 86.94,62.37 86.98,62.47 87.01,62.47 87.03,62.49 87.06,62.49 87.15,62.52 87.24,62.58 87.28,62.6 87.33,62.59 87.62,62.55 87.85,62.74 87.87,62.78 88.06,62.78
GND on IN3 (solid shape): 28.68,84.65 28.82,84.56 28.79,84.39 28.43,84.04 28.43,83.36 28.51,83.28 28.54,83.11 28.4,83.02 25.8,83.02 25.66,83.11 25.69,83.28 25.77,83.36 25.77,84.04 25.41,84.39 25.38,84.56 25.52,84.65
GND on IN3 (solid shape): 46.08,84.65 46.22,84.56 46.19,84.39 45.83,84.04 45.83,83.36 45.91,83.28 45.94,83.11 45.8,83.02 30.1,83.02 29.96,83.11 29.99,83.28 30.07,83.36 30.07,84.04 29.71,84.39 29.68,84.56 29.82,84.65
GND on IN3 (solid shape): 50.38,84.65 50.52,84.56 50.49,84.39 50.13,84.04 50.13,83.36 50.21,83.28 50.24,83.11 50.1,83.02 47.5,83.02 47.36,83.11 47.39,83.28 47.47,83.36 47.47,84.04 47.11,84.39 47.08,84.56 47.22,84.65
