# Allegro board da0ee6mbad0-d-susan-165XL-0828.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
CAM2_CSI_D0P: length 8.3
  IN3 w0.07: v1(15.15,47.63) 15.12,47.65 15.06,47.65 14.91,47.81 14.15,48.57 10.91,48.57 10.29,47.95 9.77,47.95 9.7,48.01 9.37,48.01 v1(9.3,47.95)
  BOTTOM w0.076: CN5.13 9.15,47.8 v1(9.3,47.95)
CAM2_PWDN: length 79.3
  IN3 w0.06: 50.12,71.78 50.12,70.55 v8(49.96,70.39)
  IN3 w0.064: v1(21.49,42.74) 21.49,47.19 23.16,48.87 24.33,48.87 24.61,49.15 24.61,49.53 23.95,50.19 23.95,80.75 25.02,81.82 46.81,81.82 49.4,79.23 49.4,77.34 49.86,76.88 49.86,76 50.36,75.5 50.36,74.39 50.71,74.05 50.71,73.24 50.12,72.66 50.12,71.78
  BOTTOM w0.114: R221.2 20.13,42.87 Q15.1 21.47,42.72 v1(21.49,42.74)
CAM2_PWDN_C: length 18.8
  IN3 w0.064: v1(7.05,49.08) 7.16,49.19 15.76,49.19 16,48.95 16,45.24 16.51,44.73 v1(18.72,44.73)
  BOTTOM w0.114: Q15.3 19.13,43.69 R221.1 R220.2 v1(18.72,44.73)
CAM_FLHD: length 9.2
  IN4 w0.06: v8(49.68,70.67) 49.68,70.95 49.48,71.15 49.48,71.32 49.63,71.47 49.63,71.64 49.48,71.79 49.48,71.99 49.7,72.21 50.08,72.21 50.82,72.95 50.82,73.74 50.31,74.25 50.31,74.93
  IN4 w0.127: 50.31,74.93 49.7,75.54 49.7,77.04 48.79,77.95 v1(48.79,78)
CAM_I2C_SCL_2M: length 8.5
  IN3 w0.064: v1(12.29,45.24) 12.16,45.37 11.53,45.37 10.56,46.33 7.67,46.33 7.08,46.92 7.08,47.45 6.83,47.7 6.68,47.7 v1(6.63,47.65)
  BOTTOM w0.114: CN5.17 6.75,47.52 6.63,47.65 v1(6.63,47.65)
CAM_I2C_SCL_5M: length 15.1
  IN3 w0.064: v1(18.16,63.65) 18.06,63.55 18.06,61.5 17.98,61.42 17.98,58.37 17.09,57.48 16.66,57.48 16.02,56.85 16.02,55.27 13.81,53.06 13.81,52.64 13.94,52.52 v1(14.37,52.52)
  BOTTOM w0.114: v1(18.16,63.65) 17.65,63.15 CN6.16
CAM_I2C_SDA_2M: length 8.7
  IN3 w0.064: v1(6.63,48) 6.74,47.88 6.91,47.88 7.26,47.52 7.26,46.99 7.74,46.51 10.64,46.51 11.6,45.54 12.19,45.54 12.29,45.65 v1(12.29,46.13)
  BOTTOM w0.114: CN5.5 6.45,48.17 v1(6.63,48)
CAM_I2C_SDA_5M: length 15.1
  IN3 w0.064: v1(13.48,52.52) 13.64,52.67 13.64,53.14 15.85,55.35 15.85,56.92 16.59,57.66 17.01,57.66 17.8,58.45 17.8,61.49 17.88,61.57 17.88,63.73 v1(18.16,64.01)
  BOTTOM w0.114: CN6.7 17.95,64.22 v1(18.16,64.01)
CAMERA_1_RESET#: length 91.4
  IN3 w0.064: v11(50.26,73.28) 50.52,73.53 50.52,73.97 50.17,74.31 50.17,75.42 49.67,75.92 49.67,76.79 49.2,77.27 49.2,79.16 46.73,81.63 25.29,81.63 v11(25.07,81.41) ; v1(9.31,73.49) 9.31,68.92 10.39,67.84 10.39,65.41 9.83,64.85 9.83,62.99 10.06,62.76 13.03,62.76 13.15,62.64 13.15,51.03 14.35,49.84 17.09,49.84 18.06,48.87 v1(18.06,46.34)
  IN4 w0.06: v11(50.26,73.28) 49.93,73.28 49.23,72.58 49.23,71.47 49.31,71.39 49.31,71.04 v8(49.4,70.95)
  IN4 w0.064: v11(25.07,81.41) 23.26,81.41 22.53,80.67 11.43,80.67 10.26,79.5 10.26,74.44 v1(9.31,73.49)
CAMERA_2_RESET#: length 94.7
  TOP w0.114: Q12.1 v9(8.83,67.91)
  IN3 w0.06: 49.93,71.78 49.93,71.1 49.68,70.84 49.68,70.39 49.91,70.16 49.91,69.77 v8(49.68,69.54)
  IN3 w0.064: v1(6.15,47.65) 6.14,47.65 6.14,48.82 6.7,49.38 12.62,49.38 12.75,49.51 12.75,62.05 12.49,62.31 9.55,62.31 8.83,63.03 v9(8.83,67.91) ; v11(25.52,81) 25.77,81.25 46.53,81.25 48.43,79.35 48.43,76.6 49.79,75.24 49.79,74.06 49.93,73.92 49.93,71.78
  IN4 w0.064: v11(25.52,81) 23.14,81 22.6,80.47 11.6,80.47 10.54,79.4 10.54,69.62 v9(8.83,67.91)
  BOTTOM w0.114: CN5.18 v1(6.15,47.65)
CAMERA_3_RESET#: length 13.1
  IN3 w0.06: v8(49.68,70.1) 49.48,70.3 49.48,70.87 49.74,71.13 49.74,71.78
  IN3 w0.064: 49.74,71.78 49.74,73.8 49.6,73.94 49.6,75.16 48,76.76 48,79.4 47.01,80.39 v1(47.01,80.42)
  BOTTOM w0.114: v1(47.01,80.42) 46.66,80.42 46.05,79.81 TP50.1
CH_DISABLE: length 11.6
  TOP w0.114: U12.H3 116.77,61.01 116.23,61.01 v5(115.92,60.71)
  IN2 w0.064: v5(115.92,60.71) 115.82,60.71 115.03,59.92 113.99,59.92 112.75,58.68 111.99,58.68 111.68,58.37 111.2,58.37 110.16,59.41 109.93,59.41 109.5,58.98 v4(109.32,58.98)
  IN3 w0.064: v1(110.31,57.43) 110,57.74 110,58.09 109.32,58.78 v4(109.32,58.98)
CH_DISABLE_C: length 5.3
  BOTTOM w0.114: PU7.9 106.7,55.14 107.24,55.68 107.24,56.1 PR125.2 108.17,57.03 108.97,57.03 PR139.1 PR138.1
CH_INT: length 98.1
  TOP w0.114: U12.J3 117.1,62.93 117.6,63.43 117.93,63.43 118.13,63.22 v5(118.13,63.15)
  IN2 w0.064: v4(86.38,70.79) 86.53,70.64 87.83,70.64 88.09,70.9 94.11,70.9 95.78,69.23 95.78,68.85 98.57,66.05 98.57,65.43 99.11,64.9 104.59,64.9 105.13,64.37 107.9,64.37 109.42,62.84 109.78,62.84 110.03,62.59 110.03,62.03 v4(109.72,61.72) 109.93,61.52 112.9,61.52 115.26,63.88 117.04,63.88 117.47,63.45 117.83,63.45 v5(118.13,63.15) ; v4(86.28,76.33) 85.03,77.58 83.6,77.58 82.94,78.25 80.75,78.25 80.04,77.54 70.64,77.54 69.79,78.38 69.79,78.83 69.23,79.39 66.14,79.39 65.9,79.63 58.49,79.63 56.86,81.26 49.35,81.26 48.33,80.24 48.33,79.27 48.71,78.89 49.07,78.89 49.28,78.68 49.28,77.58 47.52,75.82 v5(47.52,75.03)
  IN3 w0.064: v4(86.38,70.79) 86.38,71.24 87.14,72.01 87.14,75.19 86.28,76.05 v4(86.28,76.33) ; v4(109.72,61.72) 108.61,60.61 108.38,60.61 v1(107.97,60.2)
  BOTTOM w0.114: PR122.2 107.78,60.01 v1(107.97,60.2)
CH_INT_C: length 4.5
  BOTTOM w0.114: PR129.1 PR122.1 106.26,57.97 PU7.7
CH_OTG: length 7.2
  IN2 w0.064: v5(115.6,57.84) 115.6,57.98 115.35,58.23 115.35,58.79 114.98,59.16 113.88,59.16 112.53,57.81 110.74,57.81 v4(110.54,58.02)
  IN3 w0.064: v4(110.54,58.02) 110.51,58.02 110.41,58.12 v1(110.41,58.45)
CHG_AGND: length 2.1
  BOTTOM w0.381: PC119.1 99.3,55.64 99.67,56.01 100.53,56.01 100.76,55.78 v9(100.76,55.65)
  vias: v1(108.3,54.69) v1(108.38,58.22) v1(108.51,55.53) v1(108.66,58.45) v1(108.76,55.75) v1(108.76,54.89) v2(106.78,55.2) v2(107.01,54.94) v3(106.78,55.2) v3(107.01,54.94) v4(108.23,55.12) v5(106.78,55.2) v5(107.01,54.94) v10(108.3,54.69) v10(108.38,58.22) v10(108.51,55.53) v10(108.66,58.45) v10(108.76,55.75) v10(108.76,54.89) v11(108.3,54.69) v11(108.38,58.22) v11(108.51,55.53) v11(108.66,58.45) v11(108.76,55.75) v11(108.76,54.89)
CHG_STAT: length 21.3
  TOP w0.114: v5(117.78,63.15) 117.6,62.97 U12.J2
  IN2 w0.064: v5(117.78,63.15) 117.29,63.15 116.71,63.73 115.35,63.73 112.99,61.37 108.99,61.37 108.18,62.18 105.86,62.18 v4(105.1,61.42)
  IN3 w0.064: v1(103.88,60.2) v4(105.1,61.42)
  BOTTOM w0.114: PU7.4 104.54,59.05 PR116.1 103.88,59.7 v1(103.88,60.2)
CHG_USBDN: length 24.4
  TOP w0.076: v5(101.16,60.15) 101.24,60.22 101.24,60.64 100.75,61.14 100.38,61.14 97.99,63.53 97.99,70.22 R668.2 97.99,70.55 97.99,71.36 96.11,73.24 96.11,73.69 95.96,73.84 U11.6
  IN2 w0.07: v5(101.16,60.15) 101.16,59.91 100.61,59.36 100.61,57.46 101.5,56.57 103.67,56.57 103.95,56.85 103.95,57.17 103.98,57.2 103.98,57.2 v4(104.09,57.3)
  IN3 w0.07: v4(104.09,57.3) 104.04,57.26 v1(104.04,56.87)
CHG_USBDP: length 24
  TOP w0.076: U11.7 96.36,73.79 96.26,73.69 96.26,73.31 98.14,71.43 98.14,70.55 R668.1 98.14,70.22 98.14,63.59 100.44,61.29 100.81,61.29 101.39,60.71 101.39,60.28 v5(101.52,60.15)
  IN2 w0.07: v4(103.5,57.3) 103.6,57.3 103.78,57.13 103.78,56.92 103.6,56.75 101.57,56.75 100.78,57.53 100.78,59.29 101.34,59.84 101.34,59.97 v5(101.52,60.15)
  IN3 w0.07: v1(103.54,56.87) 103.54,57.27 v4(103.5,57.3)
CLK_USB_REF_DN: length 6.1
  IN4 w0.06: v8(57.89,70.39) 57.89,70.08 58.11,69.85 58.31,69.85 58.44,69.72 59.56,69.72 60.86,71.02 60.98,71.02
  IN4 w0.064: 60.98,71.02 62.76,71.02 v1(62.91,70.87)
CLK_USB_REF_DP: length 5.6
  IN4 w0.06: 60.98,71.53 59.32,69.86 58.51,69.86 58.27,70.1 v8(58.17,70.1)
  IN4 w0.064: v1(62.96,71.55) 62.94,71.53 60.98,71.53
CODEC_RESET#: length 34.4
  TOP w0.114: v5(108.15,68.94) 108.27,68.82 R162.1 R163.2
  IN2 w0.064: v4(98.45,73.08) 98.98,73.08 100.42,74.51 104.22,74.51 108.15,70.58 v5(108.15,68.94)
  IN3 w0.064: v4(98.45,73.08) 98.42,73.05 90.4,73.05 v11(89.3,71.96)
  IN4 w0.06: 85.65,66.27 85.65,65.53 85.48,65.37 85.48,64.55 v8(85.28,64.35)
  IN4 w0.064: 85.65,66.27 85.65,66.32 87.02,67.69 87.02,68.73 88.31,70.03 88.31,71.76 88.52,71.96 v11(89.3,71.96)
CORE_PWROK: length 53.5
  TOP w0.114: v5(66.7,78.44) R89.2 67.06,77.86 67.31,78.11 v13(67.31,78.31)
  IN2 w0.064: v4(83.84,76.61) 82.7,77.75 80.94,77.75 80.24,77.05 70.43,77.05 69.31,78.17 69.31,78.54 68.94,78.91 67.17,78.91 v5(66.7,78.44) 65.89,77.63 64.91,77.63 v4(64.55,77.27)
  IN3 w0.06: 58.65,71.78 58.65,71.55 58.11,71.02 58.11,70.79 57.76,70.44 57.37,70.44 v8(57.32,70.39) ; v8(82.88,63.95) 82.38,63.95 81.96,64.37 81.51,64.37
  IN3 w0.064: 81.51,64.37 81.12,64.37 79.55,65.94 79.55,67.57 79.12,68 78.66,68 78.56,68.1 78.56,69.75 80.37,71.56 82.97,71.56 83.47,72.06 83.47,76.23 v4(83.84,76.61) ; v4(64.55,77.27) 63.64,76.35 63.64,75.48 61.03,72.87 59.38,72.87 58.65,72.14 58.65,71.78
CPU_VREF:
  vias: v2(42.87,63.78) v3(42.87,63.78) v4(43.25,63.98) v5(42.87,63.78) v6(44.3,64.16) v7(44.3,64.16) v8(44.3,64.16)
CPVDD: length 10.4
  TOP w0.508: R383.2 124.1,78.05 124.2,77.95 v2(124.2,77.37)
  IN1 w0.508: v5(122.92,71.91) 122.92,72 123.39,72.47 123.39,76.56 v2(124.2,77.37)
  IN2 w0.254: v5(122.92,71.91) 122.79,72.04 v4(122.07,72.04)
  IN3 w0.305: v1(120.29,70.99) v1(120.77,70.99) 121.82,72.04 v4(122.07,72.04)
CPVEE: length 4.3
  IN2 w0.064: v4(120.04,70.13) 120.16,70.26 121.18,70.26 121.31,70.13 v5(122.92,70.13)
  IN3 w0.064: v4(120.04,70.13) 119.33,70.13 v1(118.9,69.7)
CPVPP: length 3.1
  IN2 w0.254: v5(122.92,71.02) 122.45,71.02 v4(122.07,71.4)
  IN3 w0.305: v1(120.27,70.59) v1(120.8,70.59) 121.26,70.59 v4(122.07,71.4)
DACDAT: length 5.2
  BOTTOM w0.114: R371.2 115.87,66.16 115.87,67.1 C325.2 116.12,68.16 116.41,68.16 117.3,69.04 U34.31
DACREF: length 5.7
  BOTTOM w0.203: C332.2 119.06,76.99 118.9,76.83 U34.10
  BOTTOM w0.508: C332.2 119.06,79.13 C333.1 119.05,79.17 119.78,79.91 120.29,79.91 120.71,80.33 L16.2
DB_ANT_B: length 2.1
  BOTTOM w0.292: CN14.1 L30.1 C373.1
DB_ANT_C: length 2.3
  BOTTOM w0.292: C374.1 L31.1 CN15.1
DBG_RESETBTN#: length 45.8
  TOP w0.114: CN1.24 v5(62.22,73.14)
  IN2 w0.064: v5(62.22,73.14) 62.36,73.14 63.15,72.35 63.86,72.35 66.56,69.65 69.41,69.65 73.03,66.03 73.03,60.86 72.74,60.57 72.74,55.14 73.4,54.48 73.4,53.77 72.95,53.32 72.95,52.71 v4(73.17,52.48)
  IN3 w0.064: v4(73.17,52.48) 73.05,52.6 71.56,52.6 67.06,57.11 62.7,57.11 62.5,57.3 61.07,57.3 60.66,57.71 58.11,57.71 v8(57.89,57.94)
DBVDD: length 7.7
  IN3 w0.381: v1(114.2,80.04) 114.2,79.7 112.11,77.61 112.11,75.03 111.25,74.17 111.25,73.51
  vias: v1(111.27,73.31) v1(111.53,73.05) v10(111.27,73.31) v10(111.53,73.05) v11(111.27,73.31) v11(111.53,73.05)
DCIN_5V_IN:
  vias: v1(144.75,77.19) v1(144.75,76.86) v1(144.75,76.53) v1(144.75,76.15) v1(145.08,77.19) v1(145.08,76.86) v1(145.08,76.53) v1(145.08,76.16) v1(145.41,77.19) v1(145.41,76.86) v1(145.41,76.53) v1(145.41,76.16) v1(145.74,74.96) v1(145.74,74.6) v1(145.74,74.27) v1(146.25,74.96) v1(146.25,74.6) v1(146.25,74.27) v1(146.75,74.6) v1(146.76,74.96) v1(146.76,74.27) v1(147.24,74.96) v1(147.25,74.6) v1(147.24,74.27) v1(147.75,74.96) v1(147.75,74.6) v1(147.75,74.25)
DCVDD: length 1.8
  BOTTOM w0.254: R361.2 C312.2 C306.1
DCVDD_C: length 1.9
  BOTTOM w0.114: R361.1 113.59,72.23 113.96,72.6 U34.42
DDI0_DDC_SCL: length 51.9
  TOP w0.114: v5(86,78.89) 86.76,78.89 87.18,79.31 R119.1
  IN2 w0.064: v5(86,78.89) 86,80.99 84.8,82.2 84,82.2 82.47,80.67 82.47,80.21 v4(82.75,79.94)
  IN3 w0.06: 51.21,71.78 51.21,71.7 51.38,71.53 v8(51.38,71.24)
  IN3 w0.064: 51.21,71.78 51.21,72.36 51.63,72.78 51.63,73.08 52.62,74.06 52.62,75.41 51.36,76.67 51.36,77.8 51.44,77.88 51.44,79.61 53.66,81.83 58.61,81.83 58.63,81.85 60.65,81.85 60.65,81.85 68.41,81.85 69.49,80.77 81.68,80.77 82.17,80.29 82.39,80.29 v4(82.75,79.94)
DDI0_DDC_SDA: length 52.1
  TOP w0.114: v5(86,82.83) 86.29,83.12 R117.1
  IN2 w0.064: v4(82.11,79.94) 82.32,80.14 82.32,80.73 83.94,82.35 84.86,82.35 85.34,81.87 86.5,81.87 86.62,81.98 86.62,82.6 86.38,82.83 v5(86,82.83)
  IN3 w0.06: v8(51.38,70.1) 51.58,70.31 51.58,71.53 51.36,71.75 51.36,71.78
  IN3 w0.064: v4(82.11,79.94) 82.11,80.11 81.61,80.62 69.42,80.62 68.36,81.68 53.74,81.68 51.59,79.54 51.59,77.75 51.51,77.67 51.51,76.73 52.77,75.47 52.77,74 51.79,73.01 51.79,72.72 51.36,72.3 51.36,71.78
DDI0_HPD#: length 35.1
  TOP w0.114: v5(67.87,80.16) 67.74,80.04 67.74,78.92 67.79,78.87 67.79,78.16 67.74,78.11 67.74,77.83 68.14,77.43 Q4.3 69.28,77.14 R93.1
  IN2 w0.064: v4(68.35,80.67) 68.22,80.54 68.22,80.52 v5(67.87,80.16)
  IN3 w0.06: 51.51,71.78 51.51,71.78 51.74,71.55 51.74,69.9 v8(51.38,69.54)
  IN3 w0.064: v4(68.35,80.67) 67.49,81.53 53.81,81.53 51.76,79.48 51.76,77.67 51.68,77.59 51.68,76.78 52.92,75.54 52.92,73.93 51.94,72.95 51.94,72.66 51.51,72.23 51.51,71.78
DDI0_RCOMP_DN: length 1.1
  IN2 w0.114: v5(57.88,60.1) 57.88,60.28 57.58,60.58 v12(57.58,60.66)
  IN3 w0.114: v12(57.58,60.66) 57.6,60.68 v8(57.6,61.05)
DDI0_RCOMP_DP: length 1.3
  IN2 w0.114: v5(57.25,60.1) 57.15,60.2 v12(57.15,60.96)
  IN3 w0.114: v12(57.15,60.96) 57.15,60.99 57.32,61.16 v8(57.32,61.33)
DDI0_TX0_DN: length 34.8
  IN2 w0.07: v4(71.68,73.79) 71.62,73.79 71.42,73.99 71.42,74.17 71.45,74.21 v5(71.78,74.21)
  IN3 w0.07: v4(71.68,73.79) 71.62,73.79 71.29,73.45 71.29,71.67 70.63,71.02 70.63,70.56 70.46,70.38 69.41,70.38 69.14,70.11 69.14,69.47 69.21,69.39 69.44,69.39 69.61,69.22 69.61,68.73 69.44,68.55 69.19,68.55 69.11,68.47 69.11,68.02 69.21,67.92 70.46,67.92 70.63,67.74 70.63,65.34 70.69,65.29 70.69,64.74 70.63,64.68 70.63,62.26 67.85,59.47 64.08,59.47 63.01,60.53 61.36,60.53 61.2,60.69 59.69,60.69 59.18,61.2 59.18,61.76 58.73,62.21 57.98,62.21 57.87,62.1 57.45,62.1 56.82,61.47 56.82,60.39 57.12,60.09 57.28,60.09 57.32,60.12 v8(57.32,60.2)
DDI0_TX0_DP: length 34.8
  IN2 w0.07: v5(71.02,74.21) 71.18,74.21 71.24,74.14 71.24,73.92 v4(71.12,73.79)
  IN3 w0.07: v8(57.6,59.92) 57.05,59.92 56.65,60.32 56.65,61.54 57.38,62.28 57.8,62.28 57.91,62.38 58.8,62.38 59.35,61.83 59.35,61.27 59.76,60.86 61.28,60.86 61.43,60.7 63.09,60.7 64.15,59.64 67.78,59.64 70.46,62.33 70.46,64.75 70.52,64.81 70.52,65.22 70.46,65.27 70.46,67.67 70.39,67.75 69.14,67.75 68.94,67.95 68.94,68.55 69.12,68.72 69.36,68.72 69.44,68.8 69.44,69.15 69.36,69.22 69.14,69.22 68.96,69.4 68.96,70.18 69.34,70.56 70.39,70.56 70.46,70.63 70.46,71.09 71.12,71.75 v4(71.12,73.79)
DDI0_TX1_DN: length 35.3
  IN2 w0.07: v4(73.2,73.79) 73.13,73.86 73.13,74.04 v5(73.3,74.21)
  IN3 w0.06: v8(58.73,60.48) 58.73,60.2 59.04,59.89 59.2,59.89
  IN3 w0.07: 59.2,59.89 59.74,59.89 59.89,60.05 60.94,60.05 61.1,59.89 62.76,59.89 63.82,58.83 68.1,58.83 71.31,62.05 71.31,62.05 71.69,62.43 71.69,62.87 71.52,63.05 71.39,63.05 71.31,63.12 71.31,63.42 71.39,63.5 71.8,63.5 71.98,63.68 71.98,64.12 71.8,64.29 71.39,64.29 71.31,64.37 71.31,64.67 71.39,64.74 71.8,64.74 71.98,64.92 71.98,65.36 71.8,65.54 71.39,65.54 71.31,65.61 71.31,65.91 71.39,65.99 71.8,65.99 71.98,66.16 71.98,66.61 71.8,66.78 71.39,66.78 71.31,66.86 71.31,67.16 71.39,67.23 71.8,67.23 71.98,67.41 71.98,67.85 71.8,68.03 71.39,68.03 71.31,68.1 71.31,68.4 71.39,68.48 71.8,68.48 71.98,68.65 71.98,69.09 71.8,69.27 70.41,69.27 70.33,69.35 70.33,69.65 70.41,69.72 71.12,69.72 71.31,69.92 71.31,70.73 72.03,71.45 72.03,72.01 73.2,73.18 v4(73.2,73.79)
DDI0_TX1_DP: length 35.3
  IN2 w0.07: v5(72.54,74.21) 72.91,74.21 72.96,74.16 72.96,74.06 72.67,73.76 v4(72.54,73.76)
  IN3 w0.07: v8(59.02,60.2) 59.02,60.16 59.07,60.11 59.11,60.07 59.67,60.07 59.82,60.22 61.01,60.22 61.17,60.07 62.83,60.07 63.89,59.01 68.03,59.01 71.14,62.12 71.14,62.12 71.52,62.5 71.52,62.8 71.45,62.88 71.32,62.88 71.14,63.05 71.14,63.49 71.32,63.67 71.73,63.67 71.81,63.75 71.81,64.05 71.73,64.12 71.32,64.12 71.14,64.3 71.14,64.74 71.32,64.92 71.73,64.92 71.81,64.99 71.81,65.29 71.73,65.37 71.32,65.37 71.14,65.54 71.14,65.98 71.32,66.16 71.73,66.16 71.81,66.24 71.81,66.53 71.73,66.61 71.32,66.61 71.14,66.79 71.14,67.23 71.32,67.4 71.73,67.4 71.81,67.48 71.81,67.78 71.73,67.86 71.32,67.86 71.14,68.03 71.14,68.47 71.32,68.65 71.73,68.65 71.81,68.73 71.81,69.02 71.73,69.1 70.33,69.1 70.16,69.28 70.16,69.72 70.33,69.9 71.05,69.9 71.14,69.99 71.14,70.81 71.86,71.52 71.86,72.08 73.03,73.25 73.03,73.45 72.72,73.76 v4(72.54,73.76)
DDI0_TX2_DN: length 34.9
  IN2 w0.07: v5(75.84,74.21) 75.72,74.21 75.69,74.18 75.69,73.84 v4(75.74,73.79)
  IN3 w0.07: v4(75.74,73.79) 75.74,72.91 75.23,72.4 74.82,72.4 74.6,72.62 74.6,73.26 74.52,73.33 74.17,73.33 74.09,73.26 74.09,72.07 73.72,71.69 73.47,71.69 73.09,72.07 72.98,72.07 72.73,71.82 72.73,71.72 73.05,71.4 73.05,70.99 72.62,70.56 72.03,70.56 71.95,70.49 71.95,70.14 72.03,70.06 72.44,70.06 72.62,69.89 72.62,62.47 68.35,58.2 63.12,58.2 62.61,58.71 59.38,58.71 58.45,59.64 v8(58.45,60.2)
DDI0_TX2_DP: length 34.9
  IN2 w0.07: v4(75.18,73.79) 75.33,73.79 75.38,73.84 75.38,73.94 75.52,74.07 75.52,74.18 75.49,74.21 v5(75.08,74.21)
  IN3 w0.07: v8(58.73,59.92) 58.62,59.81 58.62,59.71 59.45,58.88 62.68,58.88 63.19,58.37 68.27,58.37 72.44,62.54 72.44,69.81 72.37,69.89 71.96,69.89 71.78,70.07 71.78,70.56 71.96,70.73 72.54,70.73 72.88,71.07 72.88,71.33 72.56,71.64 72.56,71.89 72.91,72.24 73.16,72.24 73.54,71.86 73.64,71.86 73.92,72.14 73.92,73.33 74.1,73.5 74.59,73.5 74.77,73.33 74.77,72.69 74.89,72.57 75.16,72.57 75.57,72.98 75.57,73.46 75.44,73.59 75.26,73.59 75.18,73.66 v4(75.18,73.79)
DDI0_TX3_DN: length 36
  IN2 w0.07: v4(77.26,73.79) 77.21,73.85 77.21,74.05 v5(77.37,74.21)
  IN3 w0.07: v4(77.26,73.79) 77.13,73.66 77.13,73.34 75.4,71.61 74.55,71.61 73.24,70.3 73.24,62.22 68.58,57.56 62.88,57.56 62.35,58.09 59.17,58.09 57.85,59.4 57.85,60.42 58.01,60.57 58.01,61.04 57.91,61.14 57.91,61.47 58.19,61.75 58.54,61.75 58.71,61.58 58.71,61.08 v8(58.73,61.05)
DDI0_TX3_DP: length 36
  IN2 w0.07: v5(76.6,74.21) 77,74.21 77.03,74.17 77.03,74.07 76.91,73.94 76.91,73.71 76.86,73.66 76.58,73.66 v4(76.48,73.76)
  IN3 w0.07: v8(58.45,61.33) 58.49,61.33 58.54,61.38 58.54,61.51 58.47,61.58 58.26,61.58 58.08,61.4 58.08,61.22 58.18,61.12 58.18,60.5 58.02,60.34 58.02,59.48 59.24,58.26 62.42,58.26 62.95,57.73 68.51,57.73 73.07,62.29 73.07,70.37 74.48,71.78 75.33,71.78 76.96,73.41 76.96,73.61 76.92,73.65 76.92,73.73 76.85,73.79 76.51,73.79 v4(76.48,73.76)
DDR3_RCOMP0: length 2.7
  TOP w0.127: v5(46.48,64.92) 46.1,65.3 R30.1
  IN2 w0.127: v5(46.48,64.92) v12(47.27,64.92)
  IN3 w0.064: v8(46.28,64.45) 46.28,64.45 46.38,64.54 46.63,64.54 46.89,64.8 47.14,64.8 v12(47.27,64.92)
DDR3_RCOMP1: length 3.1
  TOP w0.127: R32.1 46.1,63.53 v5(46.48,63.91)
  IN2 w0.127: v5(46.48,63.91) v12(47.29,63.91)
  IN3 w0.06: 47.06,64.11 47.04,64.14 46.88,64.14 46.65,64.36 46.48,64.36 46.32,64.2 46.15,64.2 46.11,64.16 v8(46,64.16)
  IN3 w0.064: v12(47.29,63.91) 47.27,63.91 47.06,64.11
DDR3_RCOMP2: length 1.8
  TOP w0.127: R31.1 v5(46.48,64.42)
  IN2 w0.127: v5(46.48,64.42) v12(47.27,64.42)
  IN3 w0.064: v8(46.85,64.45) 47.24,64.45 v12(47.27,64.42)
DDR3_REF_N: length 6
  TOP w0.114: v5(42.31,64.64) 42.31,64.88 R286.2
  IN2 w0.064: v5(42.31,64.64) 41.96,64.29 v4(41.88,64.29)
  IN3 w0.06: v8(46.28,63.88) 46.18,63.78 45.12,63.78 44.48,64.42 43.23,64.42 42.97,64.16 42.01,64.16 v4(41.88,64.29)
DDR3_REF_P: length 5.2
  IN2 w0.064: v4(42.76,64.55) 42.76,64.86 v5(42.95,65.05)
  IN3 w0.06: v4(42.76,64.55) 44.52,64.55 45.17,63.9 46.02,63.9 46.2,64.08 46.37,64.08 46.48,63.96 46.48,63.87 46.55,63.8 46.77,63.8 v8(46.85,63.88)
DEBUG_CS: length 3.7
  TOP w0.114: v5(80.62,66.7) 80.03,66.7 TP5.1 79.69,67.04 R112.2
  IN2 w0.064: v5(80.62,66.7) v12(81.05,66.7)
  IN3 w0.064: v12(81.05,66.7) 81.12,66.63 v11(81.12,66.3)
  IN4 w0.06: 81.53,66.27 81.71,66.27 82.03,65.95 v8(82.08,65.95)
  IN4 w0.127: 81.53,66.27 81.15,66.27 v11(81.12,66.3)
DEBUG_I2C_CLK: length 27.4
  IN3 w0.064: v8(81.68,65.95) 81.53,66.09 81.53,67.82 81.89,68.18 82.13,68.18 84,70.05 88.08,70.05 89.15,71.12 89.56,71.12 90.8,72.37 94.97,72.37 97.33,70 97.33,64.01 97.53,63.81 v1(97.58,63.81)
  BOTTOM w0.114: v1(97.58,63.81) 97.57,63.79 PR109.2
DEBUG_I2C_DATA: length 29.7
  IN3 w0.064: v8(81.68,65.55) 81.38,65.84 81.38,67.88 81.82,68.33 82.06,68.33 83.94,70.2 87.98,70.2 89.05,71.27 89.43,71.27 90.73,72.57 95.17,72.57 97.58,70.16 v1(97.58,64.16)
  BOTTOM w0.114: PR110.2 97.16,62.84 97.16,63.78 97.55,64.16 v1(97.58,64.16)
DEBUG_SVID_ALERT_B: length 8.8
  TOP w0.114: PR64.2 74.8,59.46 75,59.26 TP61.1 76.63,59.03 v5(77.24,59.03)
  IN2 w0.064: v4(77.72,58.55) v5(77.24,59.03)
  IN3 w0.06: 81.91,60.17 v8(82.08,60.35)
  IN3 w0.064: v4(77.72,58.55) 77.95,58.55 78.53,59.13 80.16,59.13 80.51,59.49 81.22,59.49 81.91,60.17
DEBUG_SVID_CLK: length 8.4
  TOP w0.114: v5(77.24,59.59) 76.96,59.87 75.31,59.87 TP60.1 74.83,60.35 PR65.2
  IN2 w0.064: v4(77.72,59.11) v5(77.24,59.59)
  IN3 w0.064: v4(77.72,59.11) 78.03,59.11 78.51,59.59 80.31,59.59 80.39,59.67 81.07,59.67 81.35,59.95 v1(81.35,60.02)
  BOTTOM w0.114: v1(81.35,60.02) PU5.A1
DEBUG_SVID_DATA: length 8.5
  TOP w0.114: PR63.2 TP59.1 76.43,60.15 v5(77.21,60.15)
  IN2 w0.064: v4(77.7,59.67) v5(77.21,60.15)
  IN3 w0.064: v1(81,60.02) 80.84,59.87 79.35,59.87 79.25,59.77 77.8,59.77 v4(77.7,59.67)
  BOTTOM w0.114: v1(81,60.02) 81.02,60.05 81.02,60.15 81.62,60.75 PU5.B1
DMIC1_DAT: length 116.1
  TOP w0.114: v5(17.22,83.67) U2.5
  IN2 w0.064: v4(117.23,81.09) 117.07,80.93 115.03,80.93 114.53,80.42 102.59,80.42 100.3,78.13 98.12,78.13 97.02,77.04 97.02,75.19 96.76,74.92 95.86,74.92 91.58,79.2 87.14,79.2 86.4,78.46 83.53,78.46 83.21,78.78 80.53,78.78 79.82,78.07 70.86,78.07 70.33,78.6 70.33,79.89 69.01,81.21 67.51,81.21 66.65,80.34 58.79,80.34 56.22,82.91 53.32,82.91 53.24,82.83 22.02,82.83 21.64,82.45 17.04,82.45 16.61,82.02 v4(16.02,82.02) 17.22,83.21 v5(17.22,83.67)
  IN3 w0.064: v4(16.02,82.02) v1(16.02,81.52) ; v1(117.23,80.65) v4(117.23,81.09)
  BOTTOM w0.114: v1(117.23,80.65) 117.23,80.29 R376.1
DMIC_SCL: length 110.6
  TOP w0.114: v5(17.17,82.02) U2.4
  IN2 w0.064: v4(111.95,70.7) 110.53,72.12 110.53,73.46 108.92,75.07 108.24,75.07 105.81,77.5 102.24,77.5 100.2,75.46 98.27,75.46 97.57,74.77 95.77,74.77 91.49,79.05 87.58,79.05 86.83,78.3 83.47,78.3 83.15,78.63 80.59,78.63 79.88,77.92 70.8,77.92 70.17,78.54 70.17,79.82 68.97,81.03 67.64,81.03 66.77,80.16 58.76,80.16 56.16,82.76 53.49,82.76 53.41,82.68 22.09,82.68 21.44,82.02 v5(17.17,82.02) 16.67,81.52 v4(15.34,81.52)
  IN3 w0.064: v4(15.34,81.52) v1(14.88,81.52) ; v4(111.95,70.7) 112.07,70.58 v1(112.39,70.58)
  BOTTOM w0.114: C304.1 111.69,70.54 R356.2
DMIC_SCL_R: length 2.5
  BOTTOM w0.114: R356.1 113.09,70.86 113.56,71.32 113.56,71.91 113.85,72.2 U34.41
DRAM_PWROK: length 46.1
  IN4 w0.06: 60.98,64.44 60.63,64.44 59.79,63.6 59.79,59.97 58.87,59.06 58.16,59.06 57.95,58.85 57.5,58.85 56.77,59.59 56.16,59.59 56.13,59.62 47.32,59.62 47.13,59.81 47.13,62.35 47.39,62.61 47.39,63.05 46.57,63.88 v8(46.57,64.16) ; v8(82.48,63.95) 82.28,63.75 81.95,63.75 81.57,64.12 81.35,64.12
  IN4 w0.064: 81.34,64.12 81.35,64.12 ; 60.98,64.44 61.13,64.44
  IN4 w0.127: 61.13,64.44 62.68,64.44 63.57,65.33 75.18,65.33 76.02,64.49 78.58,64.49 78.95,64.12 81.34,64.12
E775AGND: length 8.5
  TOP w0.381: v9(120.94,56.81) 121.48,56.26 C124.2 121.66,56.29 121.66,57.08 121.31,57.43 C122.2 ; v9(118.08,57.2) 118.08,56.28 R176.1
  IN2 w0.254: v9(118.08,57.2) 117.6,57.68 v5(117.6,58.34)
  BOTTOM w0.381: v9(120.94,56.81) 120.81,56.81 120.42,57.2 v9(118.08,57.2)
EDP_BKLT_EN: length 27.2
  IN2 w0.064: v4(82.7,46.64) 82.7,46.71 83.21,47.22 83.21,49.16 81.92,50.45 79.94,50.45 79.52,50.87 79.52,51.09 80.16,51.73 80.16,54.19 79.65,54.7 79.65,57.52 78.25,58.92 v5(78.25,61.49)
  IN3 w0.064: v1(83.84,46.1) 83.23,46.1 v4(82.7,46.64)
  BOTTOM w0.114: v1(83.84,46.1) 83.92,46.03 83.92,41.86 84.39,41.39 PR94.2
  BOTTOM w0.254: PU6.1 85.25,40.6 84.73,41.12 PR94.2
EMMC_CLK: length 43.8
  IN2 w0.064: v4(56.99,47.04) 56.99,45.65 57.53,45.11 57.53,43.59 56.71,42.78 49.27,42.78 47.62,41.12 41.92,41.12 38.16,37.36 37.61,37.36 37.03,36.78 35.3,36.78 34.97,37.11 v5(34.33,37.11) 34.33,36.82 v4(33.8,36.3)
  IN3 w0.064: v11(56.66,47.32) 56.71,47.32 v4(56.99,47.04) ; v4(33.8,36.3) 33.74,36.23 v1(33.33,36.23)
  IN4 w0.06: v8(54.21,57.65) 54.21,57.37 54.41,57.17 54.41,57.01 54.25,56.85 54.25,56.69 54.43,56.51 54.43,55.86 55.65,54.64 55.65,53.88 56.38,53.14 56.38,53.01
  IN4 w0.064: 56.38,53.01 56.38,52.99 57.3,52.08 57.3,48.06 56.66,47.42 v11(56.66,47.32)
EMMC_CMD: length 43.5
  IN2 w0.064: v4(56.99,48.21) 57.55,47.65 57.55,45.59 57.88,45.26 57.88,43.44 56.76,42.32 49.43,42.32 47.86,40.75 42.04,40.75 37.77,36.48 34.57,36.48 v4(33.78,35.69) 33.42,35.33 v5(33.42,35.25)
  IN3 w0.064: v1(33.33,35.73) 33.73,35.73 v4(33.78,35.69) ; v4(56.99,48.21) 56.82,48.39 56.82,48.46 v11(56.69,48.59)
  IN4 w0.06: 55.99,52.88 55.34,53.53 55.34,54.59 53.84,56.08 53.84,56.54 53.92,56.62 v8(53.92,56.81)
  IN4 w0.064: v11(56.69,48.59) 56.69,48.74 56.79,48.85 56.79,52.08 55.99,52.88
EMMC_DATA_0: length 50.9
  IN2 w0.064: v4(64.64,49.35) 64.52,49.24 63.41,49.24 58.92,44.75 58.92,43.22 56.67,40.97 49.96,40.97 48.82,39.84 42.39,39.84 39.37,36.82 v5(39.37,36.25) 39.37,34.52 v4(39.32,34.47)
  IN3 w0.06: 56.05,54.59 56.05,54.92 53.79,57.18 53.79,58.31 53.76,58.34 53.72,58.46 53.72,58.59 53.92,58.79 v8(53.92,59.07)
  IN3 w0.064: 56.05,54.59 56.05,54.43 57.1,53.39 59.18,53.39 59.8,52.77 61.12,52.77 63.83,50.06 63.83,49.67 64.14,49.35 v4(64.64,49.35) ; v1(38.83,34.73) 39.05,34.73 v4(39.32,34.47)
EMMC_DATA_1: length 49
  IN2 w0.064: v4(65.2,48.77) 64.77,48.34 63.27,48.34 59.48,44.55 59.48,43.03 56.74,40.29 50.47,40.29 49.48,39.3 43.15,39.3 v4(39.97,36.12)
  IN3 w0.06: v8(54.21,58.22) 54.15,58.16 54.15,57.18 55.24,56.08 55.25,56.08 55.42,55.91 55.42,55.91
  IN3 w0.064: v4(39.97,36.12) 39.08,35.23 v1(38.83,35.23) ; v4(65.2,48.77) 65.2,49.43 61.5,53.13 59.98,53.13 59.36,53.75 57.25,53.75 56.36,54.63 56.36,54.97 55.42,55.91
EMMC_DATA_2: length 40.7
  IN2 w0.064: v4(56.99,47.65) 57.38,47.27 57.38,45.52 57.71,45.19 57.71,43.51 56.71,42.52 49.35,42.52 47.76,40.93 41.97,40.93 37.92,36.88 v4(37.61,36.88)
  IN3 w0.064: v11(56.61,47.88) 56.77,47.88 v4(56.99,47.65) ; v4(37.61,36.88) 38,36.49 38,36.09 38.11,35.98 38.49,35.98 38.74,35.73 v1(38.83,35.73)
  IN4 w0.06: 56.24,52.88 55.5,53.63 55.5,54.61 53.99,56.12 53.99,56.51 54.12,56.65 54.12,56.89 54.01,57.01 54.01,57.29 v8(53.92,57.37)
  IN4 w0.064: v11(56.61,47.88) 56.61,48.11 57.05,48.54 57.05,52.08 56.24,52.88
EMMC_DATA_3: length 42.1
  IN2 w0.064: v4(37.84,34.75) 37.84,34.82 38.53,35.51 38.53,36.48 42.24,40.19 48.19,40.19 49.7,41.71 56.91,41.71 58.42,43.22 58.42,45.82 58.57,45.98 58.57,46.46 v4(58.14,46.89)
  IN3 w0.064: v4(58.14,46.89) 58.04,46.99 58.04,47.3 v11(58.01,47.32) ; v1(38.33,34.23) 38.33,34.34 37.92,34.75 v4(37.84,34.75)
  IN4 w0.06: v8(54.49,57.37) 54.56,57.3 54.56,56.97 54.68,56.85 54.68,55.96 55.98,54.66 55.98,54.18 56.7,53.46 56.83,53.46
  IN4 w0.064: v11(58.01,47.32) 58.01,47.37 58.32,47.68 58.32,50.7 57.93,51.08 57.93,52.99 57.46,53.46 56.83,53.46
EMMC_DATA_4: length 51.2
  IN2 w0.064: v4(38.81,34.27) 39.01,34.06 39.42,34.06 39.77,34.42 39.77,35.82 39.62,35.97 39.62,36.82 42.46,39.66 49,39.66 50.11,40.77 56.72,40.77 59.1,43.15 59.1,44.67 63.3,48.87 v4(64.28,48.87)
  IN3 w0.06: 55.9,54.59 55.9,54.9 53.67,57.13 53.67,58.14 53.64,58.17 53.64,58.31 53.6,58.44 53.6,58.75 v8(53.64,58.79)
  IN3 w0.064: v4(64.28,48.87) 63.65,49.51 63.65,49.99 61.16,52.48 59.84,52.48 59.11,53.21 56.99,53.21 56.79,53.42 56.79,53.42 55.9,54.31 55.9,54.59 ; v4(38.81,34.27) 38.81,34.29 38.78,34.32 38.76,34.32 38.34,34.73 v1(38.33,34.73)
EMMC_DATA_5: length 41.1
  IN2 w0.064: v4(58.16,46.31) 58.24,46.23 58.24,43.29 56.86,41.91 49.63,41.91 48.11,40.39 42.19,40.39 37.36,35.56 v4(37.36,35.18)
  IN3 w0.064: v11(57.43,47.83) 57.43,47.78 57.45,47.75 57.45,47.02 v4(58.16,46.31) ; v4(37.36,35.18) 37.41,35.23 v1(38.33,35.23)
  IN4 w0.06: 54.56,55.92 54.56,56.66 v8(54.45,56.77)
  IN4 w0.064: v11(57.43,47.83) 57.55,47.96 57.55,50.83 57.76,51.03 57.76,52.78 57.36,53.18 56.73,53.18 55.83,54.08 55.83,54.65 54.56,55.92
EMMC_DATA_6: length 51
  IN2 w0.064: v4(39.98,36.68) 42.78,39.48 49.23,39.48 50.26,40.51 56.72,40.51 59.31,43.1 59.31,44.63 63.19,48.52 64.44,48.52 65.15,49.23 v4(65.58,49.23)
  IN3 w0.06: 56.64,54.53 56.49,54.68 56.49,55.02 54.29,57.22 54.29,57.68 54.29,58.02 54.41,58.14 54.41,58.3 54.29,58.42 54.29,58.59 54.49,58.79 v8(54.49,59.07)
  IN3 w0.064: v1(38.33,35.73) 38.36,35.73 38.6,35.49 39.08,35.49 39.62,36.02 39.62,36.32 v4(39.98,36.68) ; 56.64,54.53 57.12,54.05 57.23,54.05 57.32,53.96 59.4,53.96 60.05,53.3 61.57,53.3 65.58,49.3 v4(65.58,49.23)
EMMC_DATA_7: length 47.6
  IN2 w0.064: v4(38.88,36.22) 38.88,36.58 42.31,40.01 48.62,40.01 49.88,41.28 56.73,41.28 58.75,43.3 58.75,44.82 63.35,49.42 63.82,49.42 v4(64.21,49.81)
  IN3 w0.06: 56.21,54.54 56.21,54.94 53.92,57.22 v8(53.92,58.5)
  IN3 w0.064: v4(64.21,49.81) 64.13,49.89 64.13,50.01 61.19,52.95 59.88,52.95 59.25,53.57 57.17,53.57 56.21,54.54 ; v4(38.88,36.22) 38.87,36.23 v1(38.33,36.23)
EMMC_RCOMP: length 1.5
  TOP w0.114: R44.2 53.36,58.98 53.06,59.29 v5(53.06,59.31)
  IN2 w0.064: v12(53.07,59.74) 53.07,59.72 53.06,59.7 v5(53.06,59.31)
  IN3 w0.127: v12(53.07,59.74) v8(53.07,59.35)
EMMC_RESET: length 53.6
  IN2 w0.064: v4(63.29,49.84) 61.81,48.35 59.11,48.35 57.73,46.98 57.73,45.66 58.06,45.33 58.06,43.37 56.83,42.14 49.55,42.14 47.98,40.57 42.12,40.57 37.77,36.22 35.43,36.22 v4(34.69,35.49) 34.45,35.25 v5(34.31,35.25)
  IN3 w0.06: 55.75,54.59 55.75,54.88 53.55,57.08 53.55,58.09 53.52,58.12 53.52,58.29 53.44,58.54 53.44,58.6 53.44,59.15 v8(53.64,59.35)
  IN3 w0.064: v1(34.33,35.73) 34.44,35.73 v4(34.69,35.49) ; 55.75,54.59 55.75,54.21 56.92,53.04 59.03,53.04 59.77,52.3 60,52.3 60.86,51.45 61.68,51.45 v4(63.29,49.84)
FB1: length 39.9
  IN4 w0.254: v1(85.75,36.91) 85.75,36.9 85.75,34.34 85.19,33.78 59.2,33.78 58.49,34.49 50.26,34.49 49.55,35.2 v1(49.55,35.56)
FB2: length 39.6
  IN4 w0.254: v1(86.25,36.91) 86.25,37.06 86.02,37.29 85.5,37.29 85.32,37.11 85.32,34.7 84.81,34.19 59.81,34.19 59.08,34.93 50.82,34.93 v1(50.19,35.56)
FB3: length 39.6
  IN4 w0.254: v1(50.75,35.56) 50.92,35.38 59.25,35.38 60.07,34.57 84.6,34.57 84.91,34.88 84.91,37.29 85.34,37.72 86.2,37.72 86.77,37.16 86.77,36.92 v1(86.75,36.91)
FG_BATT_GD#: length 9.3
  TOP w0.114: PR29.2 117.5,50.67 v5(117.67,50.85)
  IN2 w0.064: v5(117.67,50.85) 117.29,51.23 117.29,54.38 115.44,56.24 115.44,57.11 115.87,57.54 115.87,58.07 v5(115.6,58.34)
FG_BATT_GD#_R: length 4.1
  TOP w0.114: TP15.1 117.21,49.52 PR29.1 117.5,49.25 v5(118.59,48.16)
  IN2 w0.064: v5(118.89,47.26) 118.59,47.57 v5(118.59,48.16)
FG_BATT_INTN: length 16.7
  TOP w0.114: PR30.2 118.7,49.52 119.06,49.87 119.06,51.12 TP21.1 ; v5(118.67,61.75) 118.57,61.84 U12.J1
  TOP w0.127: PU1.A2 118.89,48.49 118.39,49 PR30.2
  IN2 w0.064: v5(119.4,51.33) 120.01,51.94 120.01,55.27 119.61,55.68 119.61,58.8 120.06,59.26 120.06,60.48 118.79,61.75 v5(118.67,61.75)
FG_BATT_LOW: length 19.9
  TOP w0.114: v5(117.85,61.6) 117.6,61.37 U12.H2 ; 121.35,49.77 121.76,50.19 121.76,52.27 TP24.1 v5(119.76,52.76)
  TOP w0.127: PU1.C3 119.96,46.76 121.18,47.98 121.18,49.61 121.35,49.77
  IN2 w0.064: v5(119.76,52.76) 119.78,52.78 119.78,55.28 119.4,55.67 119.4,58.9 119.78,59.29 119.78,60.5 118.79,61.49 117.95,61.49 v5(117.85,61.6)
FLASH_TORCH: length 9.1
  IN4 w0.06: 50.57,75.01 50.57,74.3 50.95,73.92 50.95,72.9 49.93,71.88 v8(49.68,71.88)
  IN4 w0.127: v1(48.41,79.15) 48.51,79.15 49.83,77.83 49.83,77.22 49.92,77.13 49.92,75.66 50.57,75.01
FLASH_TRIG: length 8.3
  IN4 w0.06: v8(49.43,71.56) 49.36,71.63 49.36,72.07 49.68,72.39 50.06,72.39 50.64,72.98 50.64,73.64 50.16,74.12
  IN4 w0.064: 50.06,74.86 50.06,74.22 50.16,74.12
  IN4 w0.127: 50.06,74.86 48.41,76.51 v1(48.41,77.37)
  BOTTOM w0.114: TP49.1 47.9,76.99 48.28,77.37 v1(48.41,77.37)
FRONT_CAM_LED: length 10.6
  IN3 w0.06: 49.59,71.78 49.59,71.21 49.36,70.98 49.36,69.86 v8(49.4,69.82)
  IN3 w0.064: 49.59,71.78 49.59,73.7 49.45,73.84 49.45,75.1 47.01,77.53 47.01,79.02 v1(46.89,79.15)
GPIO0VDD: length 2.5
  IN4 w0.254: v11(88.8,63.17) v11(88.44,63.17) 87.58,63.17 87.2,63.55 v8(86.48,63.55)
  vias: v2(89.43,63.6) v2(89.68,63.37) v3(89.43,63.6) v3(89.68,63.37) v4(89.23,63.22) v5(89.43,63.6) v5(89.68,63.37)
GPIO_RCOMP18: length 2.3
  TOP w0.114: v5(57.05,70.79) 57.27,71.02 R67.1
  IN2 w0.114: v12(56.05,71.32) 56.3,71.08 56.5,71.08 56.79,70.79 v5(57.05,70.79)
  IN3 w0.127: v12(56.05,71.32) 56.19,71.19 v8(56.19,70.95)
GPIO_SOC_V1P0SX_S: length 21.8
  TOP w0.114: Q5.1 70.56,54.15 v5(70.58,54.13)
  IN2 w0.064: v5(70.58,54.13) 70.76,53.95 70.76,51.33 70.51,51.08 v4(70.48,51.08)
  IN3 w0.06: v8(55.62,57.94) 55.62,57.83 56.73,56.72 59.9,56.72 60.64,55.98 60.98,55.98
  IN3 w0.064: v4(70.48,51.08) 70.39,51.18 69.89,51.18 69.46,51.61 66.89,51.61 65.23,53.28 65.23,53.71 63.5,55.44 62.54,55.44 61.99,55.98 60.98,55.98
GPIO_SOC_V1P0SX_S_5P0: length 4.3
  TOP w0.114: U7.1 71.72,53.24 Q5.3 71.21,54.67 70.94,54.94 70.94,55.36 R101.2
GPIO_SUS1: length 16.1
  IN2 w0.064: v5(47.28,77.64) 46.66,77.01 46.66,74.78 47.77,73.66 51.03,73.66 51.18,73.51 51.18,71.5 51.66,71.02 54.43,71.02 55.01,70.44 v12(55.67,70.44)
  IN3 w0.06: v12(55.67,70.44) 55.62,70.38 55.62,70.16 55.9,69.87 v8(55.9,69.54)
GPIO_SUS2: length 16.9
  TOP w0.114: R33.1 47.78,76.15 v5(47.78,77.64)
  IN2 w0.064: v12(55.42,71.92) 55.42,71.89 55.42,71.88 54.89,71.35 51.76,71.35 51.53,71.58 51.53,73.69 51.2,74.02 47.9,74.02 47.09,74.83 47.09,76.63 47.78,77.33 v5(47.78,77.64)
  IN3 w0.06: v8(55.09,71.56) 55.1,71.56 55.32,71.78
  IN3 w0.064: 55.32,71.78 55.42,71.88 55.42,71.89 v12(55.42,71.92)
GPIO_SUS3: length 18.1
  TOP w0.114: R34.2 48.28,76.77 v5(48.28,77.64)
  IN2 w0.064: v12(55.09,70.92) 54.81,71.2 51.7,71.2 51.36,71.54 51.36,73.59 51.1,73.84 47.85,73.84 46.83,74.86 46.83,76.73 47.53,77.43 47.53,77.79 47.65,77.9 48.02,77.9 v5(48.28,77.64)
  IN3 w0.06: v12(55.09,70.92) 55.05,70.95 v8(54.49,70.95)
GPIO_SUS4: length 17.4
  TOP w0.114: R35.2 50.19,76.73 49.73,77.19 49.23,77.19 v5(48.78,77.64)
  IN2 w0.064: v5(48.78,77.64) 48.78,77.57 47.24,76.02 47.24,74.93 47.98,74.19 51.33,74.19 51.69,73.84 51.69,71.71 51.89,71.5 54.48,71.5 v12(54.92,71.94)
  IN3 w0.06: v8(54.77,71.24) 54.77,71.78
  IN3 w0.064: 54.77,71.78 54.77,71.79 v12(54.92,71.94)
GPS_ANT: length 2.3
  BOTTOM w0.292: CN8.1 44.22,20.47 44.15,20.54 C254.2 44.15,21.55 44.22,21.62 C253.1
GPS_BLANK: length 14.6
  IN4 w0.127: v1(30.59,21.44) 30.21,21.06 27.02,21.06 26.59,20.63 26.59,13.87 25.55,12.83 25.55,11.08 25.68,10.95 v1(25.68,10.82)
GPS_CAL: length 13.8
  IN4 w0.127: v1(26.57,10.82) 26.44,10.95 26.44,13.21 26.92,13.69 26.92,20.42 27.3,20.8 30.42,20.8 v1(30.59,20.64)
GPS_CLK_32K_R: length 2.1
  BOTTOM w0.114: U22.A6 30.59,20.23 29.87,19.51 R261.1
GPS_DISABLE#: length 7.6
  BOTTOM w0.114: TP43.1 33.27,9.53 33.04,9.3 33.04,6.86 32.94,6.76 31.4,6.76 31.3,6.66 CN7.26
GPS_EXT_LN_OUT: length 1.6
  BOTTOM w0.292: 37.28,17.76 U25.1
GPS_EXT_LNA_IN: length 0.9
  BOTTOM w0.292: 38.5,19.56 38.5,20.06 38.46,20.09 L9.2
GPS_HOSTREQ: length 14.7
  IN3 w0.06: 60.98,56.36 60.68,56.36 60.08,56.96 56.9,56.96 56.15,57.7 56.15,58.54 v8(55.9,58.79)
  IN3 w0.064: 60.98,56.36 62.15,56.36 62.53,55.98 63.04,55.98 v1(63.14,55.88)
  BOTTOM w0.114: v1(63.14,55.88) 63.14,55.01 62.08,53.95 60.73,53.95 59.36,52.58 TP57.1
GPS_LNA_EN: length 17.1
  IN3 w0.064: v1(30.99,20.24) 30.38,19.62 30.38,14.63 30.76,14.25 37.74,14.25 38.12,14.63 v1(38.12,16.66)
  BOTTOM w0.114: v1(38.12,16.66) 38.12,17.07 38,17.2 U27.5
GPS_REFCAP: length 2.6
  IN4 w0.127: v1(29.99,23.9) 31.39,22.51 v1(31.39,21.84)
GPS_RFIP: length 2.2
  BOTTOM w0.292: U22.D6 31.79,18.05 L6.2
GPS_SAW1_IN: length 4.7
  BOTTOM w0.292: U28.1 44.18,23.78 C252.2 C253.2
GPS_SAW1_OUT: length 0.9
  BOTTOM w0.292: C229.1 39.31,24.07 U28.4
GPS_SAW1_OUT1: length 2
  BOTTOM w0.292: C229.2 L9.1
GPS_SAW2_OUT: length 1.9
  BOTTOM w0.292: U25.4 L6.1
GPS_SYNC: length 13
  IN4 w0.127: v1(30.99,20.64) 30.6,20.25 28.8,20.25 28.57,20.02 27.61,20.02 27.33,19.74 27.33,10.95 v1(27.45,10.82)
GPS_TCXO_OUT: length 3.2
  BOTTOM w0.127: U22.E4 33.17,21.04 33.47,21.34 34.03,21.34 34.61,21.92 Y2.3
GPS_UART_CTS#_R: length 4
  IN3 w0.064: v1(30.99,22.24) 30.88,22.12 29.46,22.12 28.62,22.96 28.62,23.65 28.88,23.9 v1(29.11,23.9)
GPS_UART_RTS#_R: length 4.1
  IN3 w0.064: v1(28.22,23.9) 28.44,23.67 28.44,22.89 29.39,21.95 30.88,21.95 v1(30.99,21.84)
GPS_UART_RXD_R: length 2
  BOTTOM w0.114: U22.A2 30.46,21.97 30.23,21.97 29.92,22.28 29.17,22.28 R259.2
GPS_UART_TXD_R: length 2
  BOTTOM w0.114: R258.2 29.27,22.51 30.01,22.51 30.32,22.2 30.55,22.2 U22.A1
GPS_WAKEUP: length 85.2
  IN2 w0.064: v4(70.13,51.72) 70.02,51.82 68.74,51.82 65.07,48.15 63.35,48.15 59.69,44.48 59.69,42.96 55.11,38.39 43.05,38.39 40.26,35.59 40.26,34.57 37.97,32.28 29.44,32.28 v4(28.37,31.22)
  IN3 w0.06: v8(55.9,59.35) 56.27,58.99 56.27,57.75 56.95,57.08 60.17,57.08 60.7,56.54 60.98,56.54
  IN3 w0.064: v1(28.89,21.36) 27.12,21.36 26.46,22.02 26.46,29.31 v4(28.37,31.22) ; v4(70.13,51.72) 69.85,52 67.05,52 65.61,53.44 65.61,53.86 63.34,56.14 62.59,56.14 62.19,56.54 60.98,56.54
  IN4 w0.127: v1(30.99,21.44) 30.71,21.72 29.24,21.72 v1(28.89,21.36)
GYRO_CS: length 2
  BOTTOM w0.127: R350.2 102.6,39.74 102.09,39.23 U32.5
GYRO_INT1: length 18.6
  IN2 w0.064: v5(93.9,44.48) 93.98,44.4 94.03,44.4 94.21,44.22 94.21,39.68 93.65,39.12 93.65,37.39 94.15,36.88 99.23,36.88 100.35,38 v4(102.13,38)
  IN3 w0.064: v4(102.13,38) v1(102.77,38)
  BOTTOM w0.114: U32.7 102.69,37.93 v1(102.77,38)
GYRO_INT2: length 13.6
  TOP w0.114: U10.39 92.88,37.67 v5(92.88,36.96)
  IN2 w0.064: v5(92.88,36.96) 93.32,36.53 99.36,36.53 100.3,37.47 102.36,37.47 103.02,38.13 v4(103.02,38.38)
  IN3 w0.064: v4(103.02,38.38) 102.77,38.63 v1(102.51,38.63)
  BOTTOM w0.114: v1(102.51,38.63) 102.46,38.58 U32.6
GYRO_L: length 2.5
  TOP w0.114: R144.1 R145.2 96.92,45.15 96.89,45.11
  TOP w0.127: 96.89,45.11 U10.14
GYRO_M: length 3
  TOP w0.114: U10.15 96.39,44.82 R142.1 R133.2
GYRO_N: length 4.4
  TOP w0.114: R129.1 R130.2
  TOP w0.127: R130.2 94.05,45.33 95.54,45.33 95.89,44.98 U10.16
GYRO_SA0: length 2.6
  BOTTOM w0.114: R349.2 R348.2 100.44,41.35 U32.4
HDA_RCOMP: length 1.5
  TOP w0.114: R36.1 51.58,58.95 v5(51.94,59.31)
  IN2 w0.114: v5(51.94,59.31) 51.94,59.36 51.94,59.71 51.94,59.72 v12(51.94,59.74)
  IN3 w0.127: v12(51.94,59.74) v8(51.94,59.35)
HDMI_DDC_SCL_AP_J: length 15.4
  TOP w0.114: v5(76.5,79.76) 76.35,79.76 76.1,80.01 CN3.17 ; R120.1 86.93,77.88 Q8.3 83.97,78.64 v5(83.72,78.89)
  IN2 w0.064: v5(83.72,78.89) 83.45,79.16 80.37,79.16 79.75,78.54 78.9,78.54 v5(78.76,78.68) 77.53,79.91 76.65,79.91 v5(76.5,79.76)
HDMI_DDC_SDA_AP_J: length 15.5
  TOP w0.114: v5(84.41,81.81) 86.51,81.81 86.98,81.35 R118.1 ; T5.1 v5(79.65,78.79)
  IN2 w0.064: v5(76.3,83.01) 76.3,82.15 v5(79.65,78.79) 80.24,79.38 82.69,79.38 83.97,80.66 83.97,81.37 v5(84.41,81.81)
HDMI_TXCN_R: length 11
  TOP w0.076: R109.2 77.31,78.45 77.31,78.06 C756.2 77.31,77.19 77.31,76.42 77.03,76.14 77.03,75.94 77.14,75.83 v5(77.37,75.83)
  IN2 w0.07: v5(75.5,83.07) 75.38,82.94 75.38,82.18 75.69,81.87 75.69,79.86 76.2,79.34 77.11,79.34 77.37,79.09 77.37,78.92 v5(77.52,78.77) ; v5(77.37,74.69) 77.06,74.99 77.06,75.53 v5(77.37,75.83)
HDMI_TXCP_R: length 11
  TOP w0.076: R109.1 77.16,78.45 77.16,78.06 C466.2 77.16,77.21 77.16,76.49 76.88,76.21 76.88,75.92 76.79,75.83 v5(76.6,75.83)
  IN2 w0.07: v5(75.1,83.07) 75.21,82.96 75.21,82.11 75.52,81.79 75.52,79.79 76.13,79.17 77.04,79.17 77.19,79.01 77.19,78.93 77.03,78.77 v5(76.96,78.77) ; v5(76.6,75.83) 76.89,75.55 76.89,74.97 v5(76.6,74.69)
HDMI_TXD0N_R: length 8.4
  TOP w0.076: R106.2 75.28,78.45 75.28,78.06 C458.2 75.29,77.21 75.29,76.61 75.51,76.39 75.51,75.95 75.63,75.83 v5(75.84,75.83)
  IN2 w0.07: v5(75.49,78.77) 75.29,78.96 75.29,79.23 74.82,79.7 74.82,81.63 v5(74.9,81.71) ; v5(75.84,75.83) 75.54,75.53 75.54,74.99 v5(75.84,74.69)
HDMI_TXD0P_R: length 8.4
  TOP w0.076: v5(75.08,75.83) 75.27,75.83 75.36,75.92 75.36,76.33 75.14,76.55 75.14,77.19 C452.2 75.13,78.06 75.13,78.45 R106.1
  IN2 w0.07: v5(75.08,75.83) 75.36,75.55 75.36,74.97 v5(75.08,74.69) ; v5(74.93,78.77) 75.12,78.96 75.12,79.16 74.65,79.63 74.65,81.56 v5(74.5,81.71)
HDMI_TXD1N_R: length 10.1
  TOP w0.076: v5(73.3,75.83) 73.09,75.83 72.99,75.93 72.99,76.21 73.23,76.46 73.23,77.17 73.68,77.62 C447.2 73.25,78.06 73.25,78.45 R103.2
  IN2 w0.07: v5(73.3,75.83) 73,75.53 73,74.99 v5(73.3,74.69) ; v5(73.45,78.79) 73.28,78.97 73.28,79.12 73.35,79.2 73.61,79.2 74.19,79.78 74.19,82.96 v5(74.3,83.07)
HDMI_TXD1P_R: length 10.1
  TOP w0.076: R103.1 73.1,78.45 73.1,78.06 C437.2 72.67,77.62 73.08,77.21 73.08,76.52 72.84,76.28 72.84,75.93 72.74,75.83 v5(72.54,75.83)
  IN2 w0.07: v5(72.54,74.69) 72.82,74.97 72.82,75.55 v5(72.54,75.83) ; v5(72.89,78.79) 73.1,79 73.1,79.19 73.28,79.37 73.53,79.37 74.02,79.85 74.02,82.94 v5(73.9,83.07)
HDMI_TXD2N_R: length 10.1
  TOP w0.076: v5(71.78,75.83) 71.56,75.83 71.47,75.92 71.47,76.32 71.22,76.57 71.22,77.2 C378.2 71.22,78.06 71.22,78.45 R99.2
  IN2 w0.07: v5(73.7,81.71) 73.56,81.57 73.56,80.11 73.3,79.86 71.85,79.86 71.24,79.25 71.24,78.94 v5(71.42,78.77) ; v5(71.78,75.83) 71.47,75.53 71.47,74.99 v5(71.78,74.69)
HDMI_TXD2P_R: length 10
  TOP w0.076: R99.1 71.07,78.45 71.07,78.06 C377.2 71.07,77.2 71.07,76.51 71.32,76.25 71.32,75.92 71.23,75.83 v5(71.02,75.83)
  IN2 w0.07: v5(73.3,81.71) 73.38,81.63 73.38,80.18 73.23,80.03 71.78,80.03 71.07,79.32 71.07,78.98 v5(70.86,78.77) ; v5(71.02,74.69) 71.3,74.97 71.3,75.55 v5(71.02,75.83)
HEAD_DET#_CODEC: length 5.1
  BOTTOM w0.114: R375.1 118.13,78.59 117.77,78.23 117.77,77.27 118.1,76.95 U34.8
HEAD_DET#_R: length 4.1
  BOTTOM w0.114: D9.1 115.59,81.81 116.14,82.36 R369.2 C326.2 117.71,82.36 117.75,82.4 R378.2 118.13,82.36 R375.2
HEADSET_MIC: length 2.7
  BOTTOM w0.254: R385.1 138.34,76.06 138.25,75.97 R384.1 137.86,75.6 138.25,75.21 CN13.20
HOLD#_FLASH: length 5
  TOP w0.114: v9(60.98,40.16) 61.36,40.54 R79.1
  BOTTOM w0.114: U30.7 61.24,39.52 60.98,39.78 v9(60.98,40.16)
HOME_SCREEN: length 146.5
  TOP w0.114: Q18.5 70.68,50.65 70.51,50.83 70.51,52.05 70.2,52.35 v5(70.2,52.4) ; v5(97.2,62.38) 96.8,62.38 96.33,62.85 R670.1
  IN1 w0.064: v5(122.3,62.99) 121.87,63.43 117.32,63.43 116.56,62.66 116.56,61.29 116.3,61.04 115.85,61.04 115.41,60.61 114.86,60.61 v5(114.6,60.34)
  IN2 w0.064: v4(70.13,52.91) 70.2,52.83 v5(70.2,52.4) ; v4(88.01,66.8) 88.13,66.93 88.69,66.93 88.82,67.06 92.35,67.06 93.57,65.84 93.57,62.82 94.08,62.31 97.13,62.31 v5(97.2,62.38) 97.3,62.49 99.16,62.49 99.54,62.87 103.45,62.87 104.01,62.31 104.01,61.12 104.54,60.59 106.91,60.59 v4(107.92,61.6) 107.92,61.39 108.96,60.35 110.89,60.35 111.58,59.67 112.95,59.67 113.63,60.34 v5(114.6,60.34) ; v5(122.3,62.99) 124.61,62.99 125.54,63.92 125.54,67.4 126.66,68.52 126.66,71.47 127.99,72.8 139.9,72.8 141.32,71.38 144.65,71.38 145.06,71.78 145.06,72.16 144.88,72.34 144.12,72.34 v4(143.68,72.77)
  IN3 w0.064: v4(143.68,72.77) 143.51,72.95 v1(143.51,73.26) ; v4(88.01,66.8) 87.65,66.45 v11(87.63,66.45) ; v4(107.92,61.6) 107.77,61.75 107.16,61.75 105.25,59.84 105.25,56.67 105.89,56.03 105.89,53.82 105.38,53.32 101.47,53.32 99.11,50.95 99.11,49.27 98.89,49.05 94.64,49.05 94,48.41 93.62,48.41 93.14,48.9 89.24,48.9 89.01,48.67 84.99,48.67 84.58,49.07 83.74,49.07 82.86,48.19 79.87,48.19 76.16,51.91 76.16,53.32 75.91,53.56 74.18,53.56 73.91,53.29 73.91,52.72 73.32,52.13 71.82,52.13 71.22,52.73 70.3,52.73 v4(70.13,52.91)
  IN4 w0.06: 86.46,66.27 86.23,66.04 86.23,65.58 85.88,65.23 85.88,64.22 85.8,64.15 84.79,64.15 84.76,64.11 84.76,64.11 84.68,64.03 84.68,63.63 84.68,63.63 84.68,63.46 84.68,63.46 84.68,63.23 84.68,63.23 84.68,63.06 84.68,63.06 84.68,62.25 84.57,62.15 84.39,62.15 84.19,61.95 v8(84.08,61.95)
  IN4 w0.127: 86.46,66.27 86.64,66.45 v11(87.63,66.45)
  BOTTOM w0.114: CN13.8 144.25,73.83 143.67,73.26 v1(143.51,73.26)
HOME_SCREEN_L: length 4
  TOP w0.114: R410.2 74.54,51.3 Q18.3 72.6,51.3 72.49,51.18 72.49,50.8 72.64,50.65 Q18.2
HOME_SCREEN_S: length 21
  TOP w0.114: Q18.6 69.97,50 R337.2 69.99,50.08 70.3,50.4 70.3,51.88 69.93,52.25 69.69,52.25 v5(69.54,52.4)
  IN2 w0.064: v5(69.54,52.4) 69.52,52.43 v4(69.52,53.04)
  IN3 w0.06: 60.98,57.18 60.6,57.56 57.7,57.56 v8(56.75,58.5)
  IN3 w0.064: 60.98,57.18 61.01,57.15 62.44,57.15 62.63,56.96 66.99,56.96 69.52,54.43 v4(69.52,53.04)
HP_DET: length 26.7
  IN3 w0.064: v1(118.79,82.32) 118.92,82.2 124.48,82.2 127.66,79.02 138.58,79.02 140.36,77.24 140.36,76 141.25,75.11 v1(141.25,74.58)
HP_DET_J: length 7.3
  TOP w0.114: CN3.1 72.9,81.34 72.82,81.26 70.43,81.26 70,81.69 C81.1 T3.2 R94.1 69.38,79.76 Q4.1
HP_MIC: length 22.2
  IN3 w0.254: v1(117.37,78.04) 117.62,78.3 121.57,78.3 121.94,77.93 136.79,77.93 v1(137.86,76.86)
  BOTTOM w0.254: v1(137.86,76.86) 138.38,76.86 138.42,76.9 R385.2
HP_MIC_BIAS: length 23.3
  IN3 w0.254: v1(136.04,75.93) 127.09,75.93 126.59,76.43 122.96,76.43 121.43,77.95 118.21,77.95 117.95,77.7 117.22,77.7 116.99,77.93 116.99,78.8 v1(116.81,78.98)
  BOTTOM w0.114: R372.1 116.48,78.65 v1(116.81,78.98)
  BOTTOM w0.254: v1(136.04,75.93) 136.48,75.93 136.52,75.97 R384.2
HP_OUT_L: length 23
  IN3 w0.381: v1(139.21,74.63) 138.12,74.63 137.54,74.04 126.92,74.04 124.56,71.68 124.16,71.68 121.53,69.04 121.24,69.04 119.59,67.4 v1(119.17,67.4)
HP_OUT_R: length 22.1
  IN3 w0.381: v1(120.79,67.45) 121.01,67.45 124.48,70.92 124.88,70.92 125.87,71.91 127.24,73.28 138.73,73.28 139.72,74.27 v1(139.72,74.58)
HPGND: length 56.6
  IN2 w0.254: v4(120.8,69.88) 121.43,69.24 v5(122.92,69.24)
  IN3 w0.381: v1(139.72,76.9) 139.57,76.75 139.57,75.39 ; 139.57,75.39 137.03,75.39 136.45,74.8 126.61,74.8 124.24,72.44 123.85,72.44 121.21,69.81 120.87,69.81 v4(120.8,69.88) 120.49,69.57 119.82,69.57 v1(119.7,69.7) 119.7,69 118.41,67.71 118.41,67.08 118.85,66.63 121.27,66.63 124.79,70.16 125.19,70.16 126.18,71.15 127.55,72.52 139.06,72.52 140.28,73.74 140.28,74.98 139.87,75.39 139.57,75.39
I2C_0_SCL: length 108
  TOP w0.114: R168.1 112.47,56.12 112.47,57.28 113.4,58.21 113.96,58.21 U12.B9
  IN2 w0.064: v5(112.26,55.7) 112.53,55.7 112.89,55.35 113.94,55.35 114.75,54.54 114.75,53.85 115.44,53.16 115.62,53.16 116.79,52 116.79,50.4 118.98,48.2 119.26,48.2 v4(119.4,48.06)
  IN3 w0.06: 53.34,52.91 53.34,53.04 ; v8(51.38,58.79) 51.7,58.47 51.7,57.11 52.24,56.57 52.24,55.2 52.85,54.59
  IN3 w0.064: 53.34,52.91 53.34,50.34 52.83,49.84 52.83,49.66 52.63,49.46 52.63,48.24 52.3,47.91 52.3,46.44 53.91,44.83 53.91,43.22 55.2,41.92 64.02,41.92 64.67,41.28 67.33,41.28 72.89,35.72 80.32,35.72 81.3,36.7 82.22,36.7 83.23,35.69 101.75,35.69 102.03,35.97 102.86,35.97 104.78,37.89 104.78,38.72 106.78,40.72 107.94,40.72 109.42,42.19 113.33,42.19 118.87,47.73 118.87,48.01 119,48.13 119.33,48.13 v4(119.4,48.06) ; 53.34,53.04 52.93,53.44 52.93,53.49 52.93,53.5 52.93,54.51 52.85,54.59
I2C_0_SDA: length 107.3
  TOP w0.114: R170.1 112.7,56.17 112.7,57.18 113.49,57.98 113.96,57.98 U12.A9
  IN2 w0.064: v5(112.93,55.7) 112.93,55.69 112.91,55.67 112.91,55.58 112.96,55.53 114.02,55.53 114.93,54.61 114.93,53.92 115.51,53.34 115.69,53.34 116.96,52.07 116.96,50.47 119.06,48.38 119.25,48.38 119.4,48.53 v4(119.4,48.64)
  IN3 w0.06: v8(51.66,59.07) 51.58,58.99 51.58,58.76 51.82,58.52 51.82,57.17 52.37,56.62 52.37,55.25 53.03,54.59
  IN3 w0.064: v4(119.4,48.64) 119.4,48.57 119.15,48.31 118.92,48.31 118.69,48.08 118.69,47.8 113.26,42.37 109.34,42.37 107.87,40.9 106.71,40.9 104.61,38.79 104.61,37.97 102.79,36.15 101.96,36.15 101.68,35.87 83.31,35.87 82.29,36.88 81.23,36.88 80.24,35.9 72.96,35.9 67.41,41.45 64.74,41.45 64.1,42.1 55.28,42.1 54.09,43.29 54.09,44.9 52.48,46.51 52.48,47.84 52.8,48.16 52.8,49.38 53.01,49.58 53.01,49.76 53.51,50.27 53.51,53.04 53.06,53.49 53.06,54.56 53.03,54.59
I2C_2MP_CAM_SCL: length 53.9
  IN2 w0.064: v4(13.71,44.88) 13.87,45.04 14.22,45.04 15.29,43.97 18.92,43.97 19.94,42.95 42.29,42.95 45.21,45.87 47.88,45.87 51.03,49.02 51.23,49.02 51.33,48.92 v4(51.33,48.62)
  IN3 w0.06: v8(50.81,59.35) 50.57,59.11 50.57,58.4 50.75,58.22 50.75,56.87 51.46,56.16 51.46,54.76 51.63,54.59
  IN3 w0.064: 51.63,54.59 52.12,54.1 52.12,52.96 52.06,52.91 52.06,52.68 51.86,52.48 51.86,51.92 51.51,51.57 51.51,48.79 v4(51.33,48.62) ; v1(13.13,45.24) 13.35,45.24 v4(13.71,44.88)
I2C_2MP_CAM_SDA: length 53.1
  IN2 w0.064: v4(51.89,48.62) 51.3,49.2 50.95,49.2 47.8,46.05 45.14,46.05 42.21,43.13 20.01,43.13 19,44.15 15.36,44.15 14.3,45.21 13.97,45.21 v4(13.71,45.47)
  IN3 w0.06: 51.84,54.59 51.58,54.84 51.58,56.24 50.87,56.95 50.87,57.72 v8(51.09,57.94)
  IN3 w0.064: v1(13.13,46.13) 13.13,46.05 v4(13.71,45.47) ; v4(51.89,48.62) 51.69,48.82 51.69,51.49 52.04,51.85 52.04,52.4 52.24,52.6 52.24,54.18 51.84,54.59
I2C_4_SCL: length 58.9
  IN3 w0.064: v1(95.4,44.48) 95.31,44.57 92.31,44.57 92.12,44.38 90.22,44.38 89.44,43.6 81.91,43.6 80.97,44.55 71.2,44.55 70.32,45.43 66.53,45.43 65.22,46.74 63.48,46.74 62.6,47.63 62.48,47.63 v11(62.38,47.52)
  IN4 w0.064: v11(62.38,47.52) 62.29,47.61 61.39,47.61 59.86,46.08 55.34,46.08 53.79,47.63 53.79,50.52 52.55,51.75 52.55,53.87 51.71,54.71 51.71,55.83 51.33,56.21 51.33,56.5 v8(51.06,56.77)
  BOTTOM w0.114: v1(95.4,44.48) 95.4,44.58 94.63,45.34 U31.3 94.63,47.36 R340.1
I2C_4_SDA: length 59
  IN3 w0.064: v1(95.78,44.48) 95.51,44.74 92.21,44.74 92.04,44.57 90.15,44.57 89.35,43.78 82,43.78 81.05,44.72 71.29,44.72 70.41,45.61 66.62,45.61 65.31,46.92 63.57,46.92 62.69,47.8 62.48,47.8 v11(62.35,47.93)
  IN4 w0.064: v8(51.66,56.81) 51.46,56.6 51.46,56.29 51.86,55.88 51.86,54.79 52.73,53.93 52.73,51.84 53.97,50.6 53.97,47.71 55.41,46.26 59.77,46.26 61.31,47.8 62.23,47.8 v11(62.35,47.93)
  BOTTOM w0.114: R342.1 95.13,47.47 U31.4 95.13,45.25 95.78,44.6 v1(95.78,44.48)
I2C_5_SCL: length 109.2
  IN3 w0.064: v11(53.06,48.87) 53.31,48.62 53.31,48.54 58.39,43.46 63.78,43.46 65.05,42.19 68.04,42.19 73.58,36.65 79.8,36.65 81.78,38.63 98.04,38.63 99.29,37.39 102.91,37.39 103.63,38.1 103.63,39.12 106.24,41.73 107.59,41.73 109.09,43.23 111.42,43.23 113.98,45.79 114.31,45.79 120.05,51.53 120.05,54.06 119.99,54.13 119.99,54.92 120.14,55.07 120.27,55.07 120.32,55.02 v11(120.32,54.97)
  IN4 w0.06: v8(50.81,57.65) 50.81,57.4 50.59,57.18 50.59,56.38 50.73,56.25 50.81,56.25 51.28,55.78 51.28,55.15 51.41,55.02 51.41,54.74 51.44,54.71 51.44,54.61 51.46,54.59 51.46,54.58 51.47,54.58
  IN4 w0.064: v11(53.06,48.87) 53.01,48.87 51.86,50.01 51.86,53.04 52.12,53.29 52.12,53.93 51.47,54.58 ; v1(113.81,60.47) 114.2,60.08 114.2,59.54 113.33,58.68 113.33,57 115.44,54.89 118.92,54.89 119.27,55.25 119.56,55.25 119.76,55.04 120.24,55.04 v11(120.32,54.97)
  BOTTOM w0.114: v1(113.81,60.47) 113.98,60.47 114.21,60.24 114.21,60.14 114.12,60.05 113.64,60.05 113.38,59.79 113.38,59.36 113.79,58.95 U33.3
