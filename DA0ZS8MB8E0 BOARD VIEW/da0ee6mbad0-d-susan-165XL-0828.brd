# Allegro board da0ee6mbad0-d-susan-165XL-0828.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
I2C_5_SCL_C: length 6.8
  BOTTOM w0.114: R366.1 116.66,60.29 116.66,59.99 116.43,59.76 116.43,59.29 116.64,59.08 116.84,59.08 116.97,58.95 U33.6 118.1,58.95 118.23,59.08 118.56,59.08 118.92,58.73 120.03,58.73 120.25,58.95 120.8,58.95 120.94,58.81 CN11.5
I2C_5_SDA: length 107.7
  IN3 w0.064: v11(53.06,49.23) 53.49,48.79 53.49,48.62 58.47,43.64 63.85,43.64 65.12,42.37 68.11,42.37 73.66,36.83 79.72,36.83 81.71,38.81 98.12,38.81 99.36,37.57 102.84,37.57 103.45,38.18 103.45,39.19 106.17,41.91 107.51,41.91 109.01,43.41 111.35,43.41 113.9,45.96 114.24,45.96 119.87,51.6 119.87,53.99 119.81,54.05 119.81,54.99 120.07,55.25 120.21,55.25 v11(120.32,55.35)
  IN4 w0.06: v8(51.38,57.09) 51.09,57.09 50.85,56.84 50.85,56.69 51.03,56.52 51.03,56.29 51.43,55.88 51.43,55.2 51.56,55.07 51.56,54.66 ; 52.04,52.88 52.04,53.04
  IN4 w0.064: 52.04,53.04 52.24,53.24 52.24,53.98 51.56,54.66 ; v1(114.7,60.47) 114.37,60.14 114.37,59.47 113.51,58.6 113.51,57.08 115.52,55.07 118.84,55.07 119.2,55.42 119.63,55.42 119.83,55.22 120.19,55.22 v11(120.32,55.35) ; v11(53.06,49.23) 53.02,49.19 52.93,49.19 52.04,50.09 52.04,52.88
  BOTTOM w0.114: v1(114.7,60.47) 114.44,60.2 114.44,60.04 114.21,59.82 113.74,59.82 113.61,59.69 113.61,59.46 113.67,59.39 113.76,59.39 113.82,59.45 U33.4
I2C_5_SDA_C: length 6.7
  BOTTOM w0.114: CN11.4 120.93,59.31 120.8,59.18 120.16,59.18 119.93,58.95 119.01,58.95 118.66,59.31 118.26,59.31 118.12,59.45 U33.5 116.95,59.45 116.81,59.31 116.74,59.31 116.66,59.39 116.66,59.67 116.89,59.89 116.89,60.37 116.98,60.47 R370.1
I2C_5MP_CAM_SCL: length 59.2
  IN2 w0.064: v4(52.45,49.81) 52.34,49.92 51.92,49.92 51.56,49.56 50.92,49.56 47.75,46.38 45.16,46.38 42.09,43.32 20.13,43.32 19,44.45 15.39,44.45 13.84,46 13.84,50.42 14.27,50.85 14.55,50.85 v9(14.7,51)
  IN3 w0.06: 53.11,53.02 53.11,52.91 ; v8(51.09,59.07) 51.13,59.04 51.13,58.75 51.58,58.3 51.58,57.06 52.12,56.52 52.12,55.12 52.65,54.59
  IN3 w0.064: 52.65,54.59 52.8,54.43 52.8,53.34 53.11,53.04 53.11,53.02 ; 53.11,52.91 53.11,50.47 52.87,50.24 52.87,50.23 v4(52.45,49.81)
  BOTTOM w0.114: v9(14.7,51) 14.37,51.33 R204.2
I2C_5MP_CAM_SDA: length 58.5
  IN2 w0.064: v9(14.7,50.29) 14.7,50.47 14.5,50.67 14.35,50.67 14.02,50.34 14.02,46.08 15.47,44.63 19.07,44.63 20.2,43.5 42.02,43.5 45.08,46.56 47.68,46.56 50.85,49.73 51.49,49.73 51.84,50.09 52.17,50.09 v4(52.45,50.37)
  IN3 w0.06: 52.45,54.59 51.99,55.04 51.99,56.44 51.41,57.02 51.41,58.18 v8(51.38,58.22)
  IN3 w0.064: 52.45,54.59 52.68,54.36 52.68,53.27 52.93,53.01 52.93,50.55 52.75,50.37 v4(52.45,50.37)
  BOTTOM w0.114: v9(14.7,50.29) 13.48,51.51 R203.1
I2C_7_SCL: length 34
  IN1 w0.064: v5(59.25,69.09) 59.66,69.5 62.89,69.5 63.82,70.43 63.82,72.17 63.66,72.33 63.66,72.91 63.82,73.08 v2(63.82,73.4)
  IN2 w0.064: v5(59.25,69.09) 59.25,69.52 59.08,69.7 58.61,69.7 57.72,68.81 57.06,68.81 56.42,69.45 55.17,69.45 54.36,70.27 53.43,70.27 52.69,69.52 49.83,69.52 49.7,69.39 49.7,67.59 49.88,67.41 49.88,63.53 48.84,62.49 48.84,60.66 49.18,60.32 49.18,59.81 v4(49.48,59.51)
  IN3 w0.06: v8(49.4,57.37) 49.38,57.37 48.92,57.84 48.92,58.7 48.79,58.83 48.79,59.08 48.54,59.34 48.54,59.55 48.83,59.84 49.15,59.84 v4(49.48,59.51)
I2C_7_SDA: length 31.6
  IN1 w0.064: v2(64.22,73.4) 64.22,73.27 63.81,72.85 63.81,72.4 63.98,72.23 63.98,70.37 62.95,69.34 59.72,69.34 59.66,69.28 v5(59.66,69.09)
  IN2 w0.064: v5(59.66,69.09) 59.41,69.34 59.41,69.58 59.14,69.85 58.54,69.85 57.65,68.96 57.12,68.96 56.48,69.61 55.23,69.61 54.42,70.42 53.37,70.42 52.63,69.67 49.77,69.67 49.55,69.46 49.55,67.53 49.73,67.35 49.73,63.59 48.69,62.55 48.69,60.59 49.03,60.26 49.03,59.62 v12(48.92,59.51)
  IN3 w0.06: v12(48.92,59.51) 49.11,59.32 v8(49.11,58.79)
I2C_ACCEL_SCL: length 8.4
  BOTTOM w0.114: R389.2 165.88,75.63 165.88,79.27 166.28,79.68 U35.2
I2C_ACCEL_SDA: length 8.8
  BOTTOM w0.114: U35.3 166.96,80.48 166.39,79.91 166.01,79.91 165.63,79.53 R387.2
I2C_CODEC_SCL: length 94.8
  IN3 w0.064: v11(61.73,48.66) 61.76,48.63 62.38,48.63 63.72,47.29 65.46,47.29 66.77,45.98 70.56,45.98 70.81,45.73 79.5,45.73 80.13,45.09 81.34,45.09 82.28,44.15 87.32,44.15 87.91,44.73 89.74,44.73 89.96,44.95 91.9,44.95 92.06,45.11 96.5,45.11 97,45.62 99.89,45.62 102.87,48.6 103.78,48.6 109.96,54.78 110.35,54.78 113.53,57.96 113.53,60 115.61,62.07 115.61,68.03 115.41,68.23 112.8,68.23 v1(112.29,68.73)
  IN4 w0.06: v8(51.09,58.5) 51.09,58.22 51.29,58.02 51.46,58.02 51.58,58.14 51.74,58.14 52.14,57.74 52.14,57.57 52.02,57.44 52.02,57.3 52.14,57.17 52.14,57.01 51.99,56.85 51.99,56.69 52.14,56.53 52.14,54.92 53.21,53.85 53.21,52.93 53.24,52.9 53.24,52.88
  IN4 w0.064: 53.24,52.88 53.24,51.86 55.14,49.95 55.14,47.88 56.36,46.66 58.4,46.66 59.99,48.25 61.19,48.25 61.6,48.66 v11(61.73,48.66)
I2C_CODEC_SDA: length 94.6
  IN3 w0.064: v11(61.72,48.29) 61.88,48.45 62.31,48.45 63.65,47.11 65.39,47.11 66.7,45.8 70.48,45.8 70.73,45.55 79.42,45.55 80.06,44.92 81.26,44.92 82.21,43.97 87.4,43.97 87.98,44.55 89.81,44.55 90.03,44.78 91.98,44.78 92.14,44.93 96.57,44.93 97.08,45.44 99.96,45.44 102.95,48.43 103.85,48.43 110.03,54.61 110.43,54.61 113.71,57.89 113.71,59.93 115.79,62 115.79,68.11 115.49,68.4 112.9,68.4 112.67,68.63 v1(112.67,69.24)
  IN4 w0.06: v8(51.66,57.37) 51.74,57.29 51.74,57.01 51.86,56.89 51.86,56.65 51.71,56.5 51.71,56.35 52.02,56.03 52.02,54.87 53.09,53.8 53.09,52.93 53.06,52.9
  IN4 w0.064: 53.06,52.9 53.06,51.78 54.96,49.88 54.96,47.81 56.29,46.48 58.48,46.48 60.07,48.07 61.27,48.07 61.48,48.29 v11(61.72,48.29)
  BOTTOM w0.114: R357.2 112.26,69.43 112.44,69.24 v1(112.67,69.24)
I2C_GYRO_SCL: length 1.5
  BOTTOM w0.114: R346.2 99.14,41.71 U32.2
I2C_GYRO_SDA: length 1.6
  BOTTOM w0.114: U32.3 99.79,41.59 R347.2
I2C_PMIC_SCL: length 116.9
  IN2 w0.064: v4(82.83,48.74) 82.62,48.53 82.62,47.45 82.22,47.04 82.22,36.17 v4(82.14,36.09)
  IN3 w0.06: 52.59,53.13 52.63,53.09 52.63,52.96 ; 52.24,54.59 51.86,54.97 51.86,56.36 51.29,56.93 51.29,58.02 51.18,58.14 51.16,58.14 50.81,58.48 v8(50.81,58.79)
  IN3 w0.064: 52.63,52.96 52.63,52.46 52.47,52.3 52.47,51.69 52.06,51.28 52.06,49.58 52.42,49.22 52.42,48.3 52.11,47.99 52.11,46.11 52.4,45.82 52.4,43.47 53.22,42.65 54.21,42.65 55.13,41.73 63.94,41.73 64.6,41.07 67.21,41.07 72.75,35.53 80.4,35.53 81.37,36.5 81.84,36.5 82.14,36.2 v4(82.14,36.09) ; v4(82.83,48.74) 82.62,48.95 82.62,49.1 82.84,49.32 84.85,49.32 85.62,50.09 89.86,50.09 90.07,50.3 90.07,53.55 90.24,53.72 92,53.72 97.53,59.26 97.53,60.61 v1(97.61,60.68) 97.61,61.27 97.84,61.49 97.84,61.95 97.51,62.28 97.51,63.53 97.09,63.94 97.09,69.73 94.71,72.11 91.16,72.11 89.96,70.92 89.25,70.92 88.19,69.86 84.08,69.86 82.27,68.05 82.27,65.9 83.28,64.89 v8(83.28,64.75) ; 52.24,54.59 52.55,54.28 52.55,53.16 52.59,53.13
I2C_PMIC_SDA: length 114.4
  IN2 w0.064: v4(82.19,48.74) 82.45,48.49 82.45,47.52 82.04,47.12 82.04,36.63 v4(81.53,36.12)
  IN3 w0.06: 52.04,54.59 51.71,54.92 51.71,56.31 51.04,56.98 51.04,57.32 v8(51.09,57.37)
  IN3 w0.064: v8(83.68,64.75) 82.45,65.98 82.45,67.97 84.15,69.68 88.27,69.68 89.33,70.74 90.04,70.74 91.23,71.93 94.64,71.93 96.92,69.66 96.92,63.87 97.33,63.45 97.33,62.21 97.66,61.88 97.66,61.66 97.6,61.6 v1(97.58,61.6) 97.43,61.44 97.43,60.86 97.35,60.78 97.35,59.33 91.92,53.9 90.17,53.9 89.89,53.62 89.89,50.37 89.79,50.27 85.55,50.27 84.77,49.49 82.76,49.49 82.45,49.18 82.45,49 v4(82.19,48.74) ; 52.04,54.59 52.42,54.21 52.42,53.09 52.45,53.06 52.45,52.53 52.3,52.38 52.3,51.76 51.89,51.36 51.89,49.51 52.24,49.15 52.24,48.38 51.93,48.06 51.93,46.03 52.22,45.75 52.22,43.4 53.15,42.47 54.14,42.47 55.05,41.56 63.87,41.56 64.53,40.9 67.13,40.9 72.67,35.36 80.47,35.36 81.24,36.12 v4(81.53,36.12)
I2C_SENSOR_SCL: length 204.9
  IN1 w0.064: v2(93.55,36.21) 93.79,36.45 93.79,36.6 94.04,36.86 94.26,36.86 94.55,37.15 94.55,37.5 v5(94.38,37.67) 94.51,37.8 94.51,37.87 94.44,37.95 91.32,37.95 91.25,37.88 91.25,37.78 v5(91.34,37.69)
  IN2 w0.064: v5(94.38,37.67) 94.55,37.83 94.55,38.22 94.92,38.58 97.82,38.58 99.62,40.38 99.62,41.46 100,41.83 v4(100,42.14) 100.36,42.5 101.84,42.5 102.86,41.48 103.06,41.48 104.54,40.01 121.89,40.01 122.78,40.89 122.78,54.99 124.81,57.02 126.44,57.02 127.53,58.11 127.53,65.86 130.61,68.94 144.27,68.94 149.48,74.14 165.78,74.14 166.11,73.81 166.11,73.59 v9(166.39,73.31) ; v4(43.71,33.22) 43.94,33.46 44.04,33.46 44.53,33.94 87.67,33.94 90.83,37.11 90.98,37.11 91.18,37.31 91.18,37.53 v5(91.34,37.69) ; v4(24.51,30.68) 24.13,31.07 24.13,37.65 18.64,43.13 15.04,43.13 14.27,43.89 12.34,43.89 v4(12.21,44.02)
  IN3 w0.064: v4(100,42.14) 100,42.17 99.54,42.62 v1(99.18,42.62) ; v4(43.71,33.22) 43.25,33.69 41.89,33.69 40.1,31.9 35.76,31.9 34.31,33.35 27.57,33.35 25.12,30.9 24.72,30.9 v4(24.51,30.68) ; v1(12.63,44.35) 12.54,44.35 v4(12.21,44.02)
  BOTTOM w0.114: v9(166.39,73.31) 166.39,73.43 166.65,73.69 R389.1
I2C_SENSOR_SDA: length 214.1
  TOP w0.114: R2.1 2.7,46.42 3.45,45.67 3.45,45.06 v5(3.65,44.86)
  IN1 w0.064: v5(90.85,37.69) 91.07,37.92 91.07,37.95 91.25,38.13 94.51,38.13 94.69,37.95 94.69,37.87 v5(94.89,37.67) 94.73,37.5 94.73,37.08 94.33,36.68 94.11,36.68 93.96,36.53 93.96,36.45 v2(94.2,36.21)
  IN2 w0.064: v4(24.51,31.29) 24.3,31.5 24.3,37.72 18.72,43.31 15.11,43.31 14.35,44.07 13.08,44.07 12.44,44.71 8.1,44.71 7.95,44.55 3.96,44.55 v5(3.65,44.86) ; v5(90.85,37.69) 91,37.53 91,37.39 90.91,37.29 90.76,37.29 87.59,34.12 44.46,34.12 44.02,33.68 43.9,33.68 v4(43.71,33.87) ; v9(165.76,73.31) 165.93,73.48 165.93,73.74 165.71,73.97 149.55,73.97 144.34,68.76 130.68,68.76 127.71,65.79 127.71,58.04 126.51,56.85 124.89,56.85 122.96,54.92 122.96,40.82 121.97,39.83 104.47,39.83 102.99,41.3 102.79,41.3 101.77,42.33 100.74,42.33 v4(100.56,42.14) 99.8,41.38 99.8,40.31 97.9,38.41 94.99,38.41 94.73,38.14 94.73,37.83 v5(94.89,37.67)
  IN3 w0.064: v4(100.56,42.14) 100.5,42.14 99.97,42.67 v1(99.97,42.75) ; v4(43.71,33.87) 41.81,33.87 40.03,32.08 35.83,32.08 34.39,33.53 27.5,33.53 25.05,31.08 24.72,31.08 v4(24.51,31.29)
  BOTTOM w0.114: v9(165.76,73.31) 165.76,73.43 165.63,73.56 R387.1
I2C_SENSORHUB_SCL: length 5
  IN2 w0.064: v4(93.72,44.05) 93.39,44.38 v5(93.39,44.48)
  IN3 w0.064: v4(93.72,44.05) 93.72,43.87 93.81,43.78 94.73,43.78 v1(94.81,43.87)
  BOTTOM w0.114: v1(94.81,43.87) 94.9,43.78 94.9,43.63 94.63,43.36 U31.6 94.63,40.96 R341.1
I2C_SENSORHUB_SDA: length 5.9
  IN2 w0.064: v5(92.88,44.48) 92.88,44.35 v4(93.16,44.07)
  IN3 w0.064: v1(95.17,43.87) 94.9,43.6 93.67,43.6 93.2,44.07 v4(93.16,44.07)
  BOTTOM w0.114: v1(95.17,43.87) 95.13,43.83 U31.5 95.13,41.35 R343.1
I2C_VIO: length 1.9
  IN2 w0.381: v12(82.88,66.19) 82.95,66.12 v5(82.95,65.79)
  GND3 w0.305: v8(82.88,64.75) 82.88,66.19 v12(82.88,66.19)
  vias: v2(80.24,65.94) v2(80.59,65.94) v2(80.95,65.94)
I2CM_CLK: length 3.3
  TOP w0.114: TP7.1 81.58,67.39 v5(81.58,67.13)
  IN2 w0.064: v12(81.89,66.78) 81.58,67.08 v5(81.58,67.13)
  IN3 w0.064: v11(81.99,66.35) 81.89,66.45 v12(81.89,66.78)
  IN4 w0.06: 82.06,66.27 82.28,66.06 82.28,65.4 82.33,65.35 82.58,65.35 82.78,65.15 v8(82.88,65.15)
  IN4 w0.127: 82.06,66.27 v11(81.99,66.35)
I2CM_DATA: length 4.7
  TOP w0.114: v5(81.89,68.18) 81.43,68.63 TP8.1
  IN2 w0.064: v12(81.89,67.72) v5(81.89,68.18)
  IN3 w0.064: v12(81.89,67.72) 81.89,67.39 v11(81.99,67.29)
  IN4 w0.06: 82.42,66.27 82.68,66.01 82.68,65.43 82.76,65.35 83.01,65.35 83.21,65.15 v8(83.28,65.15)
  IN4 w0.127: 82.42,66.27 82.42,66.57 82.11,66.88 82.11,67.16 v11(81.99,67.29)
I2CM_SZ: length 3.9
  TOP w0.114: PR8.2 85.05,67.83 v5(84.68,68.2)
  IN2 w0.127: v4(85.04,67.95) 84.78,68.2 v5(84.68,68.2)
  IN3 w0.127: v11(84.99,67.21) 84.99,67.9 v4(85.04,67.95)
  IN4 w0.07: 84.95,66.27 84.95,65.57 v8(84.93,65.55)
  IN4 w0.127: 84.95,66.27 84.95,67.13 84.99,67.16 v11(84.99,67.21)
I2S_0_CLK: length 88.7
  IN3 w0.064: v11(61.03,48.82) 61.31,49.1 62.43,49.1 63.87,47.66 65.61,47.66 66.93,46.34 70.71,46.34 70.96,46.1 79.65,46.1 80.28,45.46 81.49,45.46 82.42,44.53 87.15,44.53 87.72,45.11 89.6,45.11 89.81,45.32 91.75,45.32 91.92,45.49 96.36,45.49 96.94,46.08 99.7,46.08 102.7,49.07 103.73,49.07 109.8,55.15 110.2,55.15 111.15,56.1 v1(111.15,64.8) 111.41,65.06 112.18,65.06 112.57,64.67 113.05,64.67 113.56,65.18 v11(115.01,65.18)
  IN4 w0.06: 52.39,55.08 52.39,56.85 52.31,56.93 52.31,57.29 v8(52.23,57.37) ; 53.57,53.13 53.81,52.88
  IN4 w0.064: v1(116.35,64.91) 116.09,65.18 v11(115.01,65.18) ; v11(61.03,48.82) 61.01,48.79 59.83,48.79 58.11,47.07 56.56,47.07 55.51,48.12 55.51,50.54 53.82,52.23 53.82,52.87 53.81,52.88 ; 52.39,55.08 53.57,53.9 53.57,53.13
I2S_0_FS: length 112.5
  IN2 w0.064: v4(119.22,63.76) 119.94,63.04 119.94,62.05 121.03,60.96 121.03,57.96 121.36,57.63 121.36,55.33 121.03,54.99 121.03,54.48 120.75,54.21 120.75,53.19 v4(121.1,52.83)
  IN3 w0.064: v4(119.22,63.76) 117.93,63.76 117.32,64.37 v1(117.32,65.05) ; v11(53.06,48.46) 53.06,48.15 52.86,47.95 52.86,46.91 54.28,45.5 54.28,43.37 55.36,42.29 64.17,42.29 64.82,41.64 67.54,41.64 73.09,36.09 80.16,36.09 81.15,37.09 82.39,37.09 83.42,36.06 101.6,36.06 101.88,36.34 102.71,36.34 104.42,38.05 104.42,38.91 106.61,41.1 107.77,41.1 109.27,42.6 113.05,42.6 118.34,47.88 118.34,48.92 120.61,51.2 120.61,52.34 v4(121.1,52.83)
  IN4 w0.06: 51.63,53.04 51.97,53.37 51.97,53.82 51.28,54.51 51.28,54.97 51.12,55.12 51.12,55.65 50.47,56.3 50.47,57.59 50.73,57.85 50.89,57.85 51.01,57.74 51.18,57.74 51.29,57.85 51.46,57.85 51.66,57.65 v8(51.94,57.65)
  IN4 w0.064: 51.63,53.04 51.63,49.89 v11(53.06,48.46)
I2S_0_RXD: length 105.8
  IN2 w0.064: v4(114.09,64.72) 114.27,64.54 117.88,64.54 119.76,62.66 119.76,61.95 120.85,60.86 120.85,58.14 120.56,57.86 120.56,55.96 v4(121,55.53)
  IN3 w0.06: v8(52.23,58.5) 52.14,58.42 52.14,57.02 52.6,56.57 52.6,55.27 53.31,54.56 53.31,54.47 ; 53.74,52.91 53.74,53.27
  IN3 w0.064: 53.74,53.27 53.31,53.7 53.31,54.47 ; v1(114.58,64.8) 114.5,64.72 v4(114.09,64.72) ; v4(121,55.53) 120.88,55.65 119.42,55.65 119,55.23 119,54.05 119.68,53.37 119.68,51.68 114.16,46.15 113.83,46.15 111.28,43.61 108.91,43.61 107.41,42.11 106.1,42.11 105.25,41.26 99.59,41.26 98.44,40.11 81.27,40.11 79.73,41.65 69.32,41.65 68.42,42.56 65.2,42.56 63.93,43.83 58.64,43.83 53.81,48.66 53.81,50.38 53.74,50.45 53.74,52.91
I2S_0_TXD: length 86.6
  IN3 w0.064: v11(61.41,48.82) 61.52,48.92 62.36,48.92 63.8,47.48 65.54,47.48 66.85,46.17 70.64,46.17 70.89,45.92 79.58,45.92 80.21,45.28 81.41,45.28 82.34,44.36 87.22,44.36 87.8,44.93 89.67,44.93 89.88,45.14 91.82,45.14 92,45.32 96.43,45.32 97.01,45.9 99.85,45.9 102.75,48.79 103.7,48.79 109.88,54.97 110.28,54.97 112.67,57.37 112.67,62.13 112.76,62.22 115.21,62.22 115.34,62.35 v1(115.34,64.8)
  IN4 w0.06: 52.27,55.02 52.27,55.03 52.27,55.13 52.27,55.13 52.27,56.69 v8(52.19,56.77) ; 53.58,52.88 53.42,53.04
  IN4 w0.064: 53.42,53.04 53.42,53.84 52.27,54.99 52.27,55.02 ; v11(61.41,48.82) 61.41,48.74 61.11,48.44 60.58,48.44 60.4,48.62 59.91,48.62 59.24,47.95 59.24,47.77 59,47.52 58.82,47.52 58.57,47.28 58.57,47.1 58.36,46.89 56.49,46.89 55.33,48.05 55.33,50.47 54.92,50.88 54.48,50.88 53.6,51.76 53.6,52.86 53.58,52.88
I2S_1_CLK: length 144
  IN1 w0.064: v2(160.66,79.25) 160.66,78.6 v5(160.55,78.49)
  IN2 w0.064: v4(160.68,76.96) 160.55,77.09 v5(160.55,78.49)
  IN3 w0.064: v11(54.07,52.33) 54.07,48.65 58.71,44.01 64.01,44.01 65.28,42.74 68.49,42.74 69.4,41.83 79.8,41.83 81.34,40.29 98.37,40.29 99.52,41.44 105.17,41.44 106.03,42.29 107.31,42.29 108.86,43.84 111.05,43.84 113.54,46.33 114.08,46.33 118.82,51.07 118.82,55.3 119.4,55.88 121.41,55.88 122.17,56.64 125.85,56.64 127.5,58.3 127.5,66.42 128.91,67.83 132.1,67.83 133.16,68.89 146.5,68.89 152.18,74.57 154.45,74.57 155.19,75.31 159.02,75.31 v4(160.68,76.96)
  IN4 w0.06: 52.83,54.81 52.83,55.35 52.51,55.67 v8(52.51,57.09)
  IN4 w0.064: v11(54.07,52.33) 54,52.4 54,52.96 53.72,53.24 53.72,53.93 52.83,54.81
I2S_1_FS: length 146
  IN3 w0.06: 54.33,52.91 54.2,52.91 54,53.11 54,53.24 53.62,53.62 53.62,54.43 52.85,55.2 52.85,56.51 52.35,57.02 52.35,58.28 52.45,58.38 52.45,58.56 52.23,58.79 v8(51.94,58.79)
  IN3 w0.064: 54.33,52.91 54.53,52.71 54.53,48.69 58.86,44.36 64.15,44.36 65.42,43.09 68.64,43.09 69.55,42.18 79.95,42.18 81.49,40.64 98.22,40.64 99.37,41.79 100.99,41.79 105.25,46.05 107.16,46.05 108.53,44.68 111.3,44.68 113.31,46.69 113.94,46.69 118.39,51.14 118.39,55.37 119.27,56.26 121.18,56.26 121.94,57.02 125.72,57.02 127.15,58.45 127.15,66.57 128.77,68.19 131.86,68.19 132.91,69.24 145.34,69.24 152.06,75.97 154.96,75.97 156.03,77.04 156.03,78.21 155.47,78.77 151.53,78.77 v1(151.28,79.02)
I2S_1_RXD: length 132.7
  IN3 w0.06: v8(55.34,58.79) 55.34,58.41 55.3,58.37 55.3,57.78 56.61,56.47 59.81,56.47 60.64,55.64 60.98,55.64
  IN3 w0.064: v1(150.52,79.91) 150.52,79.61 149.24,78.32 147.2,78.32 139.39,70.51 132.15,70.51 131.09,69.46 128.21,69.46 125.88,67.12 125.88,66.08 121.97,62.17 117.45,62.17 115.98,63.65 115.98,68.2 115.58,68.59 114.32,68.59 113.39,69.52 112.44,69.52 111.93,69.01 111.93,68.52 110.07,66.66 110.07,61.34 106.63,57.89 106.63,53.6 105.74,52.71 101.88,52.71 99.82,50.65 99.82,47.93 98.84,46.95 92.48,46.95 91.84,47.59 90.39,47.59 90.04,47.94 83.46,47.94 83.1,47.58 74.4,47.58 72.98,49 72.98,49.62 71.68,50.92 71.13,50.92 70.74,50.54 70.26,50.54 70.14,50.66 68.22,50.66 68.04,50.83 67.19,50.83 64.89,53.14 64.89,53.56 63.36,55.09 62.39,55.09 61.85,55.64 60.98,55.64
I2S_1_TXD: length 147.8
  IN3 w0.064: v11(54.25,52.63) 54.25,52.6 54.28,52.58 54.28,52.55 54.35,52.48 54.35,48.62 58.79,44.18 64.08,44.18 65.35,42.91 68.56,42.91 69.47,42.01 79.87,42.01 81.42,40.46 98.29,40.46 99.44,41.61 101.22,41.61 105.48,45.87 107.08,45.87 108.48,44.48 111.38,44.48 113.41,46.51 114.01,46.51 118.56,51.06 118.56,55.3 119.35,56.08 121.25,56.08 121.99,56.82 125.77,56.82 127.33,58.38 127.33,66.5 128.84,68.01 131.99,68.01 133.04,69.06 145.41,69.06 152.14,75.79 155.04,75.79 155.57,76.33 156.49,76.33 156.61,76.46 156.61,76.91 156.23,77.29 156.23,78.26 155.55,78.94 152.18,78.94 v1(151.88,79.25)
  IN4 w0.06: 52.96,54.87 52.96,55.45 52.63,55.78 52.63,56.85 52.71,56.93 52.71,57.29 v8(52.79,57.37)
  IN4 w0.064: 52.96,54.87 53.87,53.95 53.87,53.27 54.25,52.88 v11(54.25,52.63)
  BOTTOM w0.114: R398.2 150.48,80.56 150.72,80.32 151.63,80.32 151.76,80.19 151.76,79.36 v1(151.88,79.25)
I2S_2_CLK: length 126.6
  IN2 w0.064: v4(121.1,52.27) 120.57,52.81 120.57,54.31 120.85,54.59 120.85,55.17 120.39,55.63 120.39,58.19 120.67,58.47 120.67,60.78 119.58,61.88 119.58,62.59 118.31,63.86 117.75,63.86 117.27,64.34 113.98,64.34 112.39,65.93 v4(112.39,65.94)
  IN3 w0.06: v8(49.96,58.5) 50.31,58.15 50.31,56.95 51.2,56.06 51.2,54.61 51.23,54.59
  IN3 w0.064: v1(110.66,65.43) 111.17,65.94 v4(112.39,65.94) ; v4(121.1,52.27) 120.8,51.97 120.8,51.31 121.05,51.06 121.05,47.98 113.41,40.34 106.96,40.34 105.15,38.53 105.15,37.74 103.01,35.6 102.23,35.6 101.91,35.28 80.92,35.28 80.62,34.99 72.36,34.99 66.96,40.39 64.52,40.39 63.72,41.19 54.82,41.19 54.19,41.82 50.08,41.82 48.88,43.03 48.88,47.43 51.13,49.68 51.13,51.77 51.36,52 51.36,52.66 51.81,53.11 51.81,54 51.23,54.59
  BOTTOM w0.114: v1(110.66,65.43) 110.52,65.29 C307.1 110.09,65.46 R352.1
I2S_2_CODEC_CLK: length 6.8
  BOTTOM w0.114: R352.2 C310.2 111.48,67.5 111.48,68.05 111.78,68.35 113.55,68.35 114.44,69.24 114.96,69.24 115.3,69.58 U34.36
I2S_2_CODEC_FS: length 7.3
  BOTTOM w0.114: U34.35 115.7,69.09 115.64,69.04 114.52,69.04 113.61,68.13 112.51,68.13 C315.2 112.39,67.05 112.39,66.23 R360.2
I2S_2_CODEC_RXD: length 6.8
  BOTTOM w0.114: R363.2 113.28,66.21 113.28,67.05 C317.2 113.2,67.93 113.7,67.93 114.6,68.83 115.94,68.83 116.1,68.99 U34.34
I2S_2_CODEC_TXD: length 6.2
  BOTTOM w0.114: U34.33 116.5,69 116.12,68.63 115.1,68.63 114.58,68.1 114.26,68.1 C320.2 114.09,67.12 114.09,66.16 R365.2
I2S_2_FS: length 116.9
  IN2 w0.064: v4(121.1,53.39) 121.46,53.75 121.46,54.85 121.76,55.16 121.76,57.74 121.38,58.12 121.38,61.19 120.3,62.27 120.3,63.42 118.83,64.9 115.03,64.9 114.78,65.15 114.78,65.34 114.21,65.91 113.53,65.91 v4(113.43,65.81)
  IN3 w0.064: v4(121.1,53.39) 120.43,52.72 120.43,51.32 118.11,49 118.11,48.01 112.9,42.8 109.22,42.8 107.69,41.28 106.53,41.28 104.24,38.98 104.24,38.12 102.63,36.52 101.81,36.52 101.53,36.23 83.5,36.23 82.47,37.26 81.02,37.26 80.03,36.27 73.24,36.27 67.69,41.82 64.9,41.82 64.25,42.47 56.49,42.47 55.83,43.13 55.83,43.92 55.27,44.48 55.23,44.48 54.45,45.26 54.45,46.05 v11(53.49,47.02) ; v1(112.34,65.3) 112.67,65.3 113.18,65.81 v4(113.43,65.81)
  IN4 w0.06: 51.79,53.82 51.15,54.46 51.15,54.89 51,55.04 51,55.6 50.34,56.26 50.34,56.99 v8(50.25,57.09)
  IN4 w0.064: 51.79,53.82 51.79,53.47 51.46,53.14 51.46,49.61 51.33,49.48 51.33,48.55 v1(51.58,48.3) 52.21,48.3 v11(53.49,47.02)
  BOTTOM w0.114: R360.1 112.05,64.91 112.34,65.2 v1(112.34,65.3) ; R293.2 R296.2
I2S_2_RXD: length 114.7
  IN2 w0.064: v4(121.1,53.95) 121.21,54.05 121.21,54.89 121.54,55.23 121.54,57.7 121.21,58.04 121.21,61.04 120.13,62.12 120.13,63.35 118.75,64.72 114.91,64.72 v4(114.07,65.56)
  IN3 w0.064: v11(53.11,47.02) 53.36,47.27 53.62,47.27 54.63,46.25 54.63,45.33 55.23,44.73 55.27,44.73 56,44 56,43.21 56.56,42.65 64.32,42.65 64.97,42 67.84,42 73.39,36.45 79.93,36.45 80.95,37.47 82.55,37.47 83.6,36.41 101.45,36.41 101.73,36.69 102.56,36.69 104.06,38.19 104.06,39.09 106.47,41.51 107.64,41.51 109.12,42.98 111.6,42.98 113.88,45.25 114.11,45.25 120.25,51.4 120.25,53.1 v4(121.1,53.95) ; v1(112.8,64.92) 113.31,65.43 113.94,65.43 v4(114.07,65.56)
  IN4 w0.06: 51.58,53.81 51.03,54.37 51.03,54.81 50.87,54.97 50.87,55.53 50.21,56.19 50.21,56.84 50.05,57.01 50.05,57.17 50.25,57.37 v8(50.25,57.65)
  IN4 w0.064: v11(53.11,47.02) 53.11,47.14 52.22,48.03 51.46,48.03 51.15,48.34 51.15,49.58 51.28,49.71 51.28,53.24 51.58,53.54 51.58,53.81
I2S_2_TXD: length 128.9
  IN2 w0.064: v5(110.85,59.08) v4(111.53,59.08) ; v4(113.23,64.26) 113.38,64.11 117.22,64.11 117.66,63.67 118.25,63.67 119.4,62.51 119.4,61.72 120.44,60.68 120.44,58.95 120.04,58.55 120.04,55.73 120.39,55.38 120.39,52.27 120.74,51.93 121.4,51.93 121.56,51.77 121.56,51.41 121.33,51.18 121.15,51.18 v4(120.67,50.7)
  IN3 w0.06: 51.43,54.59 51.33,54.69 51.33,56.11 50.44,57 50.44,58.27 50.21,58.5 50.21,58.75 v8(50.25,58.79)
  IN3 w0.064: v4(120.67,50.7) 120.57,50.6 120.57,47.82 114.74,41.99 109.49,41.99 108.02,40.51 106.89,40.51 104.97,38.6 104.97,37.81 102.94,35.78 102.15,35.78 101.83,35.46 80.85,35.46 80.55,35.16 72.46,35.16 66.96,40.67 64.49,40.67 63.79,41.37 54.95,41.37 54.31,42 52.07,42 50.31,43.75 50.31,48.31 v1(50.21,48.41) 50.36,48.57 50.36,48.59 51.3,49.53 51.3,51.67 51.56,51.92 51.56,52.55 51.79,52.78 51.79,52.83 51.99,53.04 51.99,54.03 51.43,54.59 ; v4(111.53,59.08) 111.32,59.29 111.32,61.88 113.23,63.78 v4(113.23,64.26) 113.18,64.31 113.18,64.42 v1(113.69,64.92)
  BOTTOM w0.114: v1(50.21,48.41) 50.12,48.5 R290.2 R289.2
I2S_IRQ#: length 84.2
  TOP w0.114: v5(116.3,69.24) 116.3,69.06 116.55,68.82 R174.2
  IN2 w0.064: v5(116.3,69.24) 115.67,69.88 111.88,69.88 109.51,72.25 108.61,72.25 105.53,75.32 105.53,76.37 105.14,76.77 104,76.77 101.94,74.7 98.52,74.7 97.89,74.07 95.57,74.07 94,75.64 88.55,75.64 87.69,74.78 81.3,74.78 79.37,76.71 70.29,76.71 69.85,77.15 68.35,77.15 68.22,77.29 65.49,77.29 64.95,76.75 63.62,76.75 63.05,77.32 63.05,78.61 62.67,79 58.23,79 56.64,80.58 52.1,80.58 51.33,79.81 51.13,79.81 50.54,80.4 49.54,80.4 v5(48.78,79.64) 48.97,79.45 49.65,79.45 49.78,79.33 49.78,77.45 49.93,77.29 49.93,75.16 v5(50.06,75.03)
ICLK_ICOMP: length 2.3
  IN2 w0.114: v5(57.15,63.53) 56.51,64.16 v12(55.5,64.16)
  IN3 w0.305: v12(55.5,64.16) 55.55,64.16 v1(55.92,64.16)
ICLK_RCOMP: length 1.6
  IN2 w0.114: v12(56.11,64.59) 56.94,64.59 v5(57.15,64.39)
  IN3 w0.254: v12(56.11,64.59) 56.16,64.59 56.3,64.45 v8(56.47,64.45)
ILIMIT: length 1.9
  BOTTOM w0.114: PU7.10 106.83,54.64 107.07,54.88 107.07,55.04 PR126.1
IN1P: length 3.5
  BOTTOM w0.114: 117.58,78.98 R376.2
  BOTTOM w0.127: 117.58,78.98 116.93,78.32 116.93,76.76 116.9,76.73 U34.5
IN2P: length 1.4
  BOTTOM w0.114: C329.2 117.7,76.88 U34.7
JTAG2_TCK: length 16.4
  TOP w0.114: CN1.3 53.82,73.13 53.24,72.54 50.24,72.54 49.98,72.8 49.98,73.08 v5(49.96,73.1)
  IN2 w0.064: v5(49.96,73.1) 49.55,72.7 47.77,72.7 45.11,75.36 45.11,77.88 45.39,78.16 v5(45.41,78.16) 45.89,78.64 v5(47.78,78.64)
JTAG2_TDI: length 17.9
  TOP w0.114: v5(47.28,79.14) 46.8,79.14 46.68,79.02 R27.2 ; v5(50.67,73.1) 50.8,72.98 52.8,72.98 53.02,73.2 CN1.1
  IN2 w0.064: v5(50.67,73.1) 49.96,72.39 47.62,72.39 44.68,75.34 44.68,78.11 45.71,79.14 v5(47.28,79.14)
JTAG2_TDO: length 17.1
  TOP w0.114: v5(50.31,73.1) 50.31,72.92 50.47,72.77 53.06,72.77 53.42,73.14 CN1.2
  IN2 w0.064: v5(50.31,73.1) 49.76,72.54 47.7,72.54 44.95,75.29 44.95,78.06 45.77,78.87 47.42,78.87 47.56,79.01 47.53,79.04 47.53,79.24 47.57,79.28 47.57,79.53 47.68,79.64 v5(47.78,79.64)
JTAG2_TMS: length 15.2
  TOP w0.114: U3.A2 46.59,78.14 45.69,77.24 v5(45.41,77.24) R29.2 ; CN1.4 54.22,73.1 53.46,72.34 50.09,72.34 49.63,72.8 49.63,73.08 v5(49.6,73.1)
  IN2 w0.064: v5(49.6,73.1) 49.35,72.85 47.88,72.85 45.41,75.31 v5(45.41,77.24)
JTAG_SENSOR_SWCLK: length 68.4
  IN2 w0.064: v4(71.17,40.9) 71.17,44.32 73.51,46.66 73.51,50.01 74.11,50.61 74.11,52.48 73.94,52.66 73.94,54.38 73.05,55.27 73.05,60.44 73.34,60.73 73.34,66.17 73.25,66.26 73.25,66.27 69.56,69.96 66.74,69.96 64.92,71.78 64.92,72.67 64.51,73.08 64.08,73.08 63.7,73.46 62.48,73.46 62.27,73.66 59.69,73.66 v5(59.42,73.4) ; v5(91.89,37.67) v4(91.89,39.65)
  IN3 w0.064: v4(71.17,40.9) 71.68,41.41 79.7,41.41 81.19,39.92 91.63,39.92 v4(91.89,39.65)
JTAG_SENSOR_SWDIO: length 65.8
  IN2 w0.064: v5(91.26,39.3) 90.73,39.3 v4(90.7,39.27) ; v4(70.63,40.62) 70.63,44 73.36,46.73 73.36,50.07 73.96,50.67 73.96,52.38 73.77,52.57 73.77,53.56 73.58,53.75 73.58,54.52 72.89,55.2 72.89,60.5 73.19,60.8 73.19,66.11 69.48,69.81 66.63,69.81 63.93,72.51 63.21,72.51 62.32,73.4 v5(59.82,73.4)
  IN3 w0.064: v4(90.7,39.27) 90.2,39.77 81.11,39.77 79.62,41.26 74.48,41.26 73.48,40.26 70.99,40.26 v4(70.63,40.62)
LCD_RST#_SOC: length 93.2
  TOP w0.114: v9(61.62,40.13) 61.49,40.01 R80.2
  IN2 w0.064: v4(50.87,78.21) 50.87,78.59 52.41,80.13 56.45,80.13 58.04,78.54 62.32,78.54 62.59,78.26 62.59,77.12 64.26,75.45 64.84,75.45 65.2,75.08 67.23,75.08 67.68,75.54 69.6,75.54 70.1,75.04 70.1,73.04 70.44,72.7 71.21,72.7 71.57,72.33 73.03,72.33 75.64,69.72 75.64,63.98 74.56,62.9 74.56,61.79 74.87,61.48 74.87,55.17 75.18,54.86 75.18,54.18 75.92,53.44 75.92,47.13 75.36,46.57 75.36,45.88 73.14,43.66 73.14,39.65 72.11,38.61 63.47,38.61 62.79,37.92 60.8,37.92 60.65,38.08 60.65,38.76 60.22,39.19 60.22,39.47 60.4,39.65 61.13,39.65 v9(61.62,40.13)
  IN3 w0.064: v4(50.87,78.21) 50.92,78.16 v1(50.92,77.52)
  BOTTOM w0.114: v9(61.62,40.13) 60.63,41.12 57.5,41.12 57.27,40.9 57.27,39.96 57.58,39.65 57.58,37.26 56.75,36.44 CN9.2
LCD_SHLR: length 9.6
  BOTTOM w0.114: CN9.5 54.95,35.02 53.87,33.94 46.66,33.94 TP55.1
LCD_UPDN: length 8.5
  BOTTOM w0.114: CN9.8 53.15,34.24 53.07,34.15 47.4,34.15 TP54.1
LCM_DDC_SCL: length 15.5
  TOP w0.114: v5(57.96,36.12) 57.96,36.15 58.12,36.31 Q3.3 57.85,36.73 R673.2 56.65,35.54 55.74,35.54 R58.2
  IN2 w0.064: v5(57.96,36.12) 57.83,35.99 49.73,35.99 49.32,36.4 48.76,36.4 v4(48.38,36.02)
  IN3 w0.064: v4(48.38,36.02) 48.38,36.48 v1(48.36,36.5)
  BOTTOM w0.114: v1(48.36,36.5) 48.35,36.5 CN9.16
LCM_DDC_SDA: length 17.4
  TOP w0.114: v5(58.67,36.12) 58.67,38.61 58.39,38.89 Q2.3 57.59,38.89 57.55,38.85 R57.2 57.08,38.76 R674.2
  IN2 w0.064: v5(58.67,36.12) 58.52,36.12 58.21,35.82 49.15,35.82 v4(48.97,35.99)
  IN3 w0.064: v4(48.97,35.99) v1(48.97,36.48)
  BOTTOM w0.114: v1(48.97,36.48) 48.95,36.46 CN9.15
LID2#: length 36.9
  TOP w0.114: U12.H1 118.72,61.34 119.2,61.83 121.38,61.83 121.69,62.13 v5(121.69,62.46) ; HE1.2 105.34,80.03 R161.2 104.26,78.96 104.26,77.65 104.58,77.33 D8.2 v5(104.8,76.35)
  IN2 w0.064: v5(121.69,62.46) 121.69,63.76 118.06,67.39 114.93,67.39 114.68,67.64 114.68,68.04 115.7,69.06 115.7,69.46 115.43,69.72 113.32,69.72 112.83,69.24 109.76,69.24 104.8,74.2 v5(104.8,76.35)
LIGHT_SCL: length 3.7
  IN2 w0.064: v5(8.13,44.35) 8.53,44.35 8.56,44.32 v4(8.58,44.32)
  IN3 w0.064: v1(9.01,44.35) 8.99,44.32 v4(8.58,44.32)
  BOTTOM w0.114: v1(9.01,44.35) R8.1
LIGHT_SDA: length 4
  TOP w0.114: U1.2 3.58,44.35 3.07,44.86 3.07,45.07 R2.2
LPC_AD0: length 130.5
  TOP w0.114: CN1.7 55.42,72.95 55.42,72.95 v5(55.42,72.85)
  IN2 w0.064: v5(55.42,72.85) 55.55,72.85 57.1,71.29 57.42,71.29 57.61,71.1 60.39,71.1 61.19,71.89 61.97,71.89 62.67,71.2 63.31,71.2 66.01,68.5 68.81,68.5 71.85,65.46 71.85,61.41 71.57,61.13 71.57,59.63 70.76,58.82 70.76,55.06 71.57,54.24 71.57,51.71 72.03,51.25 72.03,50.31 71.59,49.87 70.58,49.87 v4(70.46,49.99) 70.03,49.56 69.47,49.56 69.24,49.79 67.76,49.79 65.38,47.41 63.66,47.41 60.44,44.19 60.44,42.67 57.53,39.76 v4(57.53,38.15)
  IN3 w0.06: 60.98,55.22 60.68,55.22 60.57,55.11 58.71,55.11 58.44,55.38 58.44,56.02 58.24,56.23 56.19,56.23 ; v8(54.77,58.79) 54.71,58.72
  IN3 w0.064: v4(57.53,38.15) 56.91,37.53 56.91,36.38 55.49,34.96 45.41,34.96 44.67,35.7 41.1,35.7 40.45,35.05 40.45,34.25 39.47,33.28 36.33,33.28 34.86,34.75 24.67,34.75 23.24,33.32 23.24,31.04 22.09,29.89 22.09,24.16 20.5,22.56 v1(20.5,22.43) ; 54.71,58.72 54.71,58.47 54.96,58.22 54.96,57.45 56.19,56.23 ; v4(70.46,49.99) 70.39,50.06 70.23,50.06 70,50.3 68.07,50.3 67.89,50.48 67.04,50.48 64.53,52.99 64.53,53.42 63.21,54.74 62.2,54.74 61.71,55.22 60.98,55.22
LPC_AD1: length 131.8
  TOP w0.114: v5(55.42,72.49) 55.6,72.49 55.82,72.72 CN1.8
  IN2 w0.064: v5(55.42,72.49) 55.62,72.49 56.99,71.13 57.35,71.13 57.56,70.92 60.44,70.92 61.25,71.73 61.9,71.73 62.6,71.03 63.24,71.03 65.94,68.33 68.44,68.33 69.01,67.76 69.01,67.05 69.23,66.84 70.22,66.84 71.69,65.37 71.69,61.48 71.41,61.2 71.41,59.7 70.56,58.85 70.56,55.03 71.41,54.17 71.41,51.54 71.87,51.08 71.87,50.38 71.52,50.03 71.07,50.03 70.72,50.38 70.27,50.38 v4(69.83,49.95) 67.69,49.95 65.31,47.58 63.59,47.58 60.27,44.26 60.27,42.74 57.17,39.64 57.17,37.95 57.46,37.66 57.92,37.66 v4(58.09,37.82)
  IN3 w0.06: v8(54.49,58.5) 54.55,58.31 54.7,58.16
  IN3 w0.064: v4(58.09,37.82) 58.06,37.82 57.22,36.98 57.22,36.46 55.56,34.8 45.34,34.8 44.6,35.54 41.16,35.54 40.61,34.98 40.61,34.18 39.54,33.11 36.26,33.11 34.79,34.58 24.73,34.58 23.4,33.25 23.4,30.97 22.26,29.82 22.26,23.69 v1(20.5,21.93) ; v4(69.83,49.95) 69.68,50.11 68.03,50.11 67.82,50.31 66.97,50.31 64.37,52.92 64.37,53.29 63.08,54.57 62.13,54.57 61.84,54.86 58.62,54.86 58.13,55.35 57.85,55.35 57.8,55.4 57.43,55.4 57.3,55.53 56.71,55.53 54.7,57.55 54.7,58.16
LPC_AD2: length 133.3
  TOP w0.114: v5(56.18,72.77) 56.22,72.81 CN1.9
  IN2 w0.064: v5(56.18,72.77) 56.85,72.1 58.02,72.1 58.38,71.74 60.56,71.74 61.05,72.22 62.11,72.22 62.81,71.53 63.49,71.53 66.19,68.83 68.99,68.83 72.21,65.61 72.21,61.28 71.9,60.97 71.9,59.5 71.09,58.68 71.09,55.19 71.9,54.38 71.9,51.85 72.38,51.37 72.38,49.37 70.53,47.52 v4(70.33,47.52) 70.33,48.23 69.1,49.46 67.89,49.46 65.52,47.08 63.8,47.08 60.77,44.05 60.77,42.53 59.38,41.15 59.38,38.99 58.85,38.46 v4(58.85,38.36)
  IN3 w0.064: v4(70.33,47.52) 69.95,47.91 66.82,47.91 v11(65.94,48.79) ; v1(20.5,21.43) 22.42,23.36 22.42,29.76 23.57,30.9 23.57,33.18 24.8,34.42 34.72,34.42 36.19,32.95 39.61,32.95 40.78,34.11 40.78,34.91 41.23,35.37 44.54,35.37 45.27,34.63 55.63,34.63 58.85,37.86 v4(58.85,38.36)
  IN4 w0.06: 56.77,54.62 55.42,55.97 55.42,56.24 55.55,56.38 55.55,56.52 55.42,56.65 55.42,56.89 55.62,57.09 v8(55.62,57.37)
  IN4 w0.064: 56.77,54.62 56.77,54.41 57.05,54.12 58.29,54.12 61,51.41 64.21,51.41 65.94,49.68 v11(65.94,48.79)
LPC_AD3: length 133.8
  TOP w0.114: v5(56.59,72.72) 56.62,72.76 CN1.10
  IN2 w0.064: v4(59.41,38.36) 59.55,38.5 59.55,41.08 60.93,42.46 60.93,43.98 63.86,46.92 65.59,46.92 67.96,49.29 69.03,49.29 69.77,48.55 v4(69.77,47.45) 70.08,47.14 70.46,47.14 72.55,49.23 72.55,51.44 72.07,51.92 72.07,54.45 71.26,55.26 71.26,58.62 72.07,59.43 72.07,60.91 72.37,61.21 72.37,65.7 69.08,68.99 66.26,68.99 63.56,71.69 62.87,71.69 62.18,72.39 61.49,72.39 61.43,72.45 58.73,72.45 58.54,72.26 57.05,72.26 v5(56.59,72.72)
  IN3 w0.064: v11(60.34,51.56) 60.65,51.26 61.38,51.26 64.22,48.42 65.93,48.42 66.61,47.74 69.48,47.74 v4(69.77,47.45) ; v1(20.5,20.93) 22.59,23.02 22.59,29.69 23.73,30.83 23.73,33.12 24.87,34.25 34.65,34.25 36.12,32.78 39.68,32.78 40.94,34.05 40.94,34.85 41.3,35.21 44.47,35.21 45.2,34.47 55.69,34.47 57.94,36.72 58.35,36.72 59.41,37.78 v4(59.41,38.36)
  IN4 w0.06: v8(55.34,57.65) 55.34,57.37 55.14,57.17 55.14,57 55.29,56.85 55.29,56.69 55.13,56.53 55.13,56.35 55.29,56.19 55.29,55.93 56.46,54.76 56.46,54.54 57,54 58.18,54 58.55,53.63
  IN4 w0.064: 58.55,53.63 60.34,51.83 v11(60.34,51.56)
LPC_CLKOUT_1: length 134
  TOP w0.114: v5(57.17,71.73) 57.17,72 C70.1 57.42,72.28 CN1.12
  IN2 w0.064: v5(57.17,71.73) 57.3,71.73 57.46,71.57 57.65,71.38 57.65,71.38 57.77,71.26 60.32,71.26 61.12,72.06 62.04,72.06 62.74,71.36 63.4,71.36 66.1,68.66 68.9,68.66 72.02,65.55 72.02,61.32 71.74,61.04 71.74,59.57 70.93,58.75 70.93,55.12 71.74,54.31 71.74,51.78 72.22,51.3 72.22,50 v4(72.03,49.81) 71.33,49.11 69.68,49.11 69.17,49.62 67.82,49.62 65.45,47.25 63.73,47.25 60.6,44.12 60.6,42.6 59,41 59,39.09 v4(58.26,38.36)
  IN3 w0.06: 56.24,56.35 58.29,56.35 58.59,56.05 58.59,55.41 58.76,55.23 60.36,55.23 60.58,55.45 60.98,55.45
  IN3 w0.064: v8(55.06,58.5) 55.14,58.42 55.14,57.45 56.24,56.35 ; v4(58.26,38.36) 58.07,38.55 56.55,38.55 55.72,37.72 55.72,35.74 55.33,35.35 45.57,35.35 44.83,36.08 40.94,36.08 40.07,35.21 40.07,34.41 39.31,33.66 36.49,33.66 35.01,35.13 24.51,35.13 21.57,32.2 21.57,30.92 19,28.35 v1(19,28.11) ; 60.98,55.45 61.72,55.45 62.26,54.9 63.28,54.9 64.7,53.49 64.7,53.06 67.11,50.64 67.96,50.64 68.14,50.46 70.06,50.46 70.18,50.35 71.02,50.35 71.31,50.06 71.78,50.06 v4(72.03,49.81)
  BOTTOM w0.114: v1(19,28.11) 19.1,28.01 19.1,25.5 18.95,25.35 18.95,23.67 19.1,23.52 19.1,23.5 19.66,22.93 CN2.6
LPC_CLKRUN#: length 62.4
  TOP w0.114: v5(58.01,72.85) 57.82,73.04 CN1.13
  IN2 w0.064: v5(58.01,72.85) 58.01,72.95 58.16,73.1 58.49,73.1 58.63,72.96 61.66,72.96 61.72,72.9 62.39,72.9 63.09,72.2 63.8,72.2 66.5,69.5 69.35,69.5 72.88,65.97 72.88,60.95 72.59,60.66 72.59,55.08 73.17,54.49 73.17,53.76 72.77,53.35 72.77,52.15 73.21,51.71 73.21,46.79 72.39,45.97 69.77,45.97 v4(68.48,47.27)
  IN3 w0.064: v11(59.92,51.54) 60.39,51.07 61.3,51.07 64.14,48.23 65.85,48.23 66.81,47.27 v4(68.48,47.27)
  IN4 w0.06: 56.31,54.38 56.31,54.74 55.17,55.89 55.17,56.14 55.01,56.29 55.01,56.69 v8(55.09,56.77)
  IN4 w0.127: v11(59.92,51.54) 59.92,51.95 58.02,53.85 56.85,53.85 56.31,54.38
LPC_FRAME#: length 134.4
  TOP w0.114: v5(56.99,72.72) 57.02,72.75 CN1.11
  IN2 w0.064: v4(59.97,38.38) 59.97,38.63 59.71,38.89 59.71,41.01 61.1,42.4 61.1,43.91 63.93,46.75 65.65,46.75 68.03,49.13 68.91,49.13 69.49,48.54 69.49,47.7 v4(69.16,47.37) 69.59,46.94 70.53,46.94 72.71,49.12 72.71,51.51 72.23,51.99 72.23,54.52 71.42,55.33 71.42,58.55 72.23,59.36 72.23,60.84 72.54,61.14 72.54,65.77 69.15,69.16 66.35,69.16 63.65,71.86 62.94,71.86 62.25,72.55 61.58,72.55 61.51,72.62 58.51,72.62 58.41,72.52 57.2,72.52 v5(56.99,72.72)
  IN3 w0.064: v11(59.48,51.59) 59.48,51.56 60.19,50.85 61.24,50.85 64.06,48.04 65.77,48.04 66.89,46.92 68.71,46.92 v4(69.16,47.37) ; v1(20.5,20.43) 22.76,22.69 22.76,29.62 23.9,30.76 23.9,33.05 24.94,34.09 34.58,34.09 36.05,32.62 39.75,32.62 41.11,33.98 41.11,34.78 41.37,35.04 44.4,35.04 45.14,34.3 55.76,34.3 58.01,36.55 58.42,36.55 59.97,38.1 v4(59.97,38.38)
  IN4 w0.06: v8(54.77,57.09) 54.84,57.03 54.84,55.98 56.13,54.68
  IN4 w0.064: v11(59.48,51.59) 59.48,52.05 57.84,53.69 56.78,53.69 56.13,54.34 56.13,54.68
LPC_RCOMP: length 1.4
  IN2 w0.114: v12(54.77,59.74) 54.77,59.72 54.73,59.68 v5(54.73,58.75)
  IN3 w0.127: v12(54.77,59.74) v8(54.77,59.35)
LPC_SERIRQ: length 58.9
  TOP w0.114: CN1.14 58.22,73.14 58.39,72.98 v5(58.39,72.85)
  IN2 w0.064: v4(72.11,47.7) 73.05,48.65 73.05,51.65 72.59,52.11 72.59,53.39 73.01,53.81 73.01,54.14 72.95,54.21 72.76,54.21 72.44,54.53 72.44,54.58 71.61,55.41 71.61,58.47 72.44,59.29 72.44,60.73 72.73,61.03 72.73,65.85 69.23,69.35 66.44,69.35 63.74,72.05 63.02,72.05 62.33,72.74 61.66,72.74 61.59,72.81 58.43,72.81 v5(58.39,72.85)
  IN3 w0.064: v4(72.11,47.7) 72.11,47.99 71.34,48.76 69.34,48.76 69.02,49.08 67.43,49.08 v11(67.33,49.18)
  IN4 w0.06: 58.95,54.35 58.63,54.67 57.77,54.67 57.43,55.02 57.43,55.27 56.75,55.94 v8(56.75,57.37)
  IN4 w0.064: 58.95,54.35 59.2,54.1
  IN4 w0.127: 59.2,54.1 59.44,54.1 60.88,52.66 61.57,52.66 62.13,52.1 65.3,52.1 67.33,50.06 v11(67.33,49.18)
LRCK: length 4.6
  BOTTOM w0.114: R377.2 117.64,66.15 117.64,67.1 C331.2 117.24,68.28 118.1,69.13 U34.29
M0_A_ZQ0: length 5.6
  IN3 w0.06: 29.74,72.18 30.38,72.18 v8(30.51,72.31)
  IN3 w0.064: v1(25.17,72) 25.38,71.78 27.35,71.78 27.75,72.18 29.74,72.18
M0_A_ZQ1: length 6.8
  IN3 w0.06: v8(31.01,72.31) 30.82,72.31 30.49,71.97 29.74,71.97
  IN3 w0.064: v1(25.17,70.09) 26.63,71.55 27.43,71.55 27.85,71.97 29.74,71.97
M0_B_ZQ0: length 4.3
  IN4 w0.064: v1(34.06,80.25) 33.8,80 33.8,79.66 32.01,77.86 v8(32.01,76.81)
M0_B_ZQ1: length 4.6
  IN4 w0.064: v8(32.01,76.31) 31.79,76.53 31.79,78.17 33.17,79.55 v1(33.17,80.25)
M1_A_ZQ0: length 3.4
  IN4 w0.127: v8(35.01,52.66) v1(35.01,49.3)
M1_A_ZQ1: length 4.3
  IN4 w0.127: v1(35.96,49.3) 35.27,49.99 35.27,52.89 v8(35.01,53.16)
M1_B_ZQ0: length 7.4
  IN3 w0.064: v1(25.3,57.15) 25.57,56.87 25.57,55.25 26.44,54.38 30.29,54.38 v8(30.51,54.16)
M1_B_ZQ1: length 6.5
  IN3 w0.064: v8(31.01,54.16) 30.86,54.16 30.63,53.93 30.07,53.93 29.87,54.13 26.31,54.13 25.3,55.14 v1(25.3,55.37)
M_0_CA0: length 43.9
  IN2 w0.089: v12(30.5,79.83) 30.5,80.21 30.6,80.32 32.41,80.32 32.64,80.09 32.64,78.72 32.74,78.61 32.9,78.61 33,78.72 33,79.1 33.11,79.2 33.26,79.2 33.36,79.1 33.36,78.74 33.46,78.64 33.61,78.64 33.72,78.74 33.72,79.1 33.82,79.2 33.97,79.2 34.07,79.1 34.07,78.74 34.17,78.64 34.32,78.64 34.43,78.74 34.43,79.1 34.53,79.2 34.68,79.2 34.78,79.1 34.78,78.74 34.88,78.64 35.04,78.64 35.14,78.74 35.14,79.1 35.24,79.2 35.39,79.2 35.49,79.1 35.49,78.74 35.59,78.64 35.75,78.64 35.85,78.74 35.85,79.1 35.95,79.2 36.1,79.2 36.2,79.1 36.2,78.72 36.31,78.61 36.46,78.61 36.56,78.72 36.56,79.1 36.66,79.2 36.81,79.2 36.92,79.1 36.92,78.72 37.02,78.61 37.17,78.61 37.27,78.72 37.27,79.1 37.37,79.2 37.53,79.2 37.63,79.1 37.63,78.72 37.73,78.61 37.88,78.61 37.98,78.72 37.98,79.1 38.08,79.2 38.24,79.2 38.34,79.1 38.34,78.03 38.44,77.93 39.42,77.93 45.31,72.04 45.31,70.28 45.46,70.13 45.46,69.27 v12(45.31,69.11)
  IN3 w0.06: v8(46.28,68.97) 45.45,68.97 v12(45.31,69.11)
  IN3 w0.064: v8(35.01,76.81) 35.01,77.79 33.55,79.25 31.49,79.25 v11(30.91,79.83) v12(30.5,79.83) v1(30.5,80.25)
  IN4 w0.064: v8(30.51,75.31) 30.22,75.59 29.82,75.59 29.31,76.1 29.31,77.7 30.91,79.3 v11(30.91,79.83)
M_0_CA1: length 46.3
  IN2 w0.089: v12(31.39,79.83) 31.65,79.83 31.75,79.73 31.75,76.79 31.85,76.68 32.01,76.68 32.11,76.79 32.11,77.27 32.21,77.37 32.36,77.37 32.46,77.27 32.46,76.79 32.57,76.68 32.72,76.68 32.82,76.79 32.82,77.32 32.92,77.42 33.07,77.42 33.18,77.32 33.18,76.79 33.28,76.68 33.43,76.68 33.53,76.79 33.53,77.32 33.63,77.42 33.79,77.42 33.89,77.32 33.89,76.79 33.99,76.68 34.14,76.68 34.24,76.79 34.24,77.32 34.34,77.42 34.5,77.42 34.6,77.32 34.6,76.79 34.7,76.68 34.85,76.68 34.95,76.79 34.95,77.32 35.06,77.42 35.21,77.42 35.31,77.32 35.31,76.79 35.41,76.68 35.56,76.68 35.66,76.79 35.66,77.32 35.77,77.42 35.92,77.42 36.02,77.32 36.02,76.79 36.12,76.68 36.27,76.68 36.38,76.79 36.38,77.32 36.48,77.42 36.63,77.42 36.73,77.32 36.73,76.79 36.83,76.68 36.99,76.68 37.09,76.79 37.09,77.32 37.19,77.42 37.34,77.42 37.44,77.32 37.44,76.79 37.54,76.68 39.77,76.68 44.8,71.65 44.8,70.41 44.7,70.31 44.7,69.67 44.9,69.47 44.9,68.8 44.95,68.75 v12(44.95,68.73)
  IN3 w0.06: v12(44.95,68.73) 45,68.69 v8(46,68.69)
  IN3 w0.064: v8(35.01,76.31) 35.25,76.55 35.25,78.89 34.64,79.5 32.13,79.5 v11(31.8,79.83) v12(31.39,79.83) v1(31.39,80.25)
  IN4 w0.064: v11(31.8,79.83) 31.77,79.83 29.51,77.57 29.51,76.46 29.92,76.05 30.6,76.05 30.73,75.92 30.73,75.52 30.86,75.39 30.92,75.39 v8(31.01,75.31)
M_0_CA2: length 45.3
  IN2 w0.089: v12(32.28,79.83) 32.28,77.75 32.41,77.62 32.65,77.62 32.75,77.73 32.75,78.18 32.85,78.28 33,78.28 33.11,78.18 33.11,77.73 33.21,77.62 33.36,77.62 33.46,77.73 33.46,78.18 33.56,78.28 33.72,78.28 33.82,78.18 33.82,77.73 33.92,77.62 34.07,77.62 34.17,77.73 34.17,78.18 34.27,78.28 34.43,78.28 34.53,78.18 34.53,77.73 34.63,77.62 34.78,77.62 34.88,77.73 34.88,78.21 34.99,78.31 35.14,78.31 35.24,78.21 35.24,77.73 35.34,77.62 35.49,77.62 35.59,77.73 35.59,78.21 35.7,78.31 35.85,78.31 35.95,78.21 35.95,77.73 36.05,77.62 36.2,77.62 36.31,77.73 36.31,78.21 36.41,78.31 36.56,78.31 36.66,78.21 36.66,77.73 36.76,77.62 36.92,77.62 37.02,77.73 37.02,78.23 37.12,78.34 37.27,78.34 37.37,78.23 37.37,77.72 37.47,77.62 37.62,77.62 37.72,77.72 37.72,78.21 37.82,78.31 37.97,78.31 38.07,78.21 38.07,77.7 38.15,77.62 39.32,77.62 45.06,71.88 v12(45.06,69.98)
  IN3 w0.06: v12(45.06,69.98) 45.23,69.8 45.23,69.7 45.68,69.26 v8(46,69.26) ; 35.61,77.57 35.56,77.52
  IN3 w0.064: 35.61,77.57 35.91,77.88 35.91,79.71 35.79,79.83 v11(32.69,79.83) v12(32.28,79.83) v1(32.28,80.24) ; 35.56,77.52 35.48,77.45 35.48,76.28 v8(35.01,75.81)
  IN4 w0.064: v11(32.69,79.83) 30.91,78.06 30.32,78.06 29.71,77.45 29.71,76.68 29.84,76.56 30.67,76.56 30.76,76.47 30.76,76.23 30.91,76.07 31.16,76.07 31.29,75.95 31.29,75.52 v8(31.51,75.31)
M_0_CA3: length 47.2
  IN2 w0.089: v12(44.45,69.39) 44.45,70.59 44.55,70.69 44.55,71.5 39.62,76.43 30.55,76.43 30.45,76.53 30.45,76.73 30.55,76.84 31.39,76.84 31.49,76.94 31.49,77.13 31.39,77.23 30.53,77.23 30.43,77.33 30.43,77.48 30.53,77.59 31.39,77.59 31.49,77.69 31.49,77.84 31.39,77.94 30.53,77.94 30.43,78.04 30.43,78.2 30.53,78.3 31.37,78.3 31.47,78.4 31.47,78.55 31.37,78.65 30.53,78.65 30.43,78.75 30.43,78.91 30.53,79.01 31.39,79.01 31.49,79.11 31.49,79.38 31.39,79.48 28.57,79.48 v12(28.22,79.83)
  IN3 w0.06: v8(44.87,69.26) 44.59,69.26 v12(44.45,69.39)
  IN3 w0.064: v1(27.84,80.25) 27.84,80.21 v12(28.22,79.83) 28.5,79.55 v11(28.5,79.5) 28.57,79.43 28.98,79.43 29.16,79.25 30.83,79.25 31.29,78.79 32.69,78.79 34.51,76.97 v8(34.51,76.81)
  IN4 w0.064: v8(30.51,74.81) 29.33,74.81 28.9,75.24 28.9,77.93 29.59,78.61 29.59,79.17 29.46,79.3 28.7,79.3 v11(28.5,79.5)
M_0_CA4: length 47.3
  IN2 w0.089: v12(45.41,68.12) 45.82,68.53 45.82,70.18 45.56,70.44 45.56,72.21 38.33,79.45 37.33,79.45 37.23,79.55 37.23,80.09 37.13,80.19 36.95,80.19 36.85,80.09 36.85,79.55 36.75,79.45 36.6,79.45 36.5,79.55 36.5,80.09 36.39,80.19 36.24,80.19 36.14,80.09 36.14,79.55 36.04,79.45 35.89,79.45 35.79,79.55 35.79,79.73 35.68,79.83 35.53,79.83 35.43,79.73 35.43,79.55 35.33,79.45 35.18,79.45 35.07,79.55 35.07,79.73 34.97,79.83 34.82,79.83 34.72,79.73 34.72,79.55 34.62,79.45 34.46,79.45 34.36,79.55 34.36,79.73 34.26,79.83 34.11,79.83 34.01,79.73 34.01,79.55 33.91,79.45 33.75,79.45 33.65,79.55 33.65,79.73 33.55,79.83 33.4,79.83 33.3,79.73 33.3,79.55 33.19,79.45 33.04,79.45 32.94,79.55 32.94,80.47 32.84,80.57 29.18,80.57 28.93,80.32 v12(28.93,79.86)
  IN3 w0.06: v8(46.57,68.12) 46.28,68.12 46.08,67.92 45.92,67.92 45.72,68.12 v12(45.41,68.12)
  IN3 w0.064: v1(28.72,80.25) 28.72,80.06 v12(28.93,79.86) v11(29.23,79.55) 29.31,79.48 30.93,79.48 31.39,79.02 32.92,79.02 34.76,77.18 34.76,76.56 v8(34.51,76.31)
  IN4 w0.064: v11(29.23,79.55) 29.94,79.55 30.1,79.4 30.1,78.82 29.11,77.83 29.11,75.41 29.49,75.03 30.78,75.03 v8(31.01,74.81)
M_0_CA5: length 48.3
  IN2 w0.089: v12(46.68,69.14) 46.68,69.67 45.82,70.54 45.82,72.32 37.69,80.44 35.87,80.44 35.77,80.34 35.77,80.19 35.67,80.09 35.52,80.09 35.42,80.19 35.42,80.34 35.32,80.44 35.16,80.44 35.06,80.34 35.06,80.19 34.96,80.09 34.81,80.09 34.71,80.19 34.71,80.72 34.6,80.82 34.45,80.82 34.35,80.72 34.35,80.19 34.25,80.09 34.1,80.09 33.99,80.19 33.99,80.72 33.89,80.82 33.74,80.82 33.64,80.72 33.64,80.21 33.54,80.11 33.38,80.11 33.28,80.21 33.28,80.71 33.17,80.82 28.6,80.82 v12(27.5,79.73)
  IN3 w0.06: v12(46.68,69.14) 46.68,69.09 46,68.41 v8(46,68.12)
  IN3 w0.064: v8(33.01,76.31) 33.01,77.25 32.92,77.34 32.69,77.34 32.58,77.45 32.58,77.9 32.51,77.98 32.38,77.98 32.31,77.9 32.31,77.75 32.23,77.67 32.1,77.67 32.03,77.75 32.03,78.03 31.95,78.11 28.52,78.11 27.94,78.69 27.94,79.38 v11(27.84,79.48) 27.58,79.73 v12(27.5,79.73) 26.99,80.25 v1(26.95,80.25)
  IN4 w0.064: v11(27.84,79.48) 27.94,79.38 27.94,78.59 28.29,78.23 28.29,74.78 29.59,73.48 30.83,73.48 v8(31.01,73.31)
M_0_CA6: length 48.4
  IN2 w0.089: v12(27.53,79.12) 27.12,79.53 27.12,79.94 28.27,81.08 35.01,81.08 35.11,80.98 35.11,80.8 35.21,80.7 35.37,80.7 35.47,80.8 35.47,80.98 35.57,81.08 35.72,81.08 35.82,80.98 35.82,80.82 35.92,80.72 36.08,80.72 36.18,80.82 36.18,80.98 36.28,81.08 36.43,81.08 36.53,80.98 36.53,80.82 36.64,80.72 36.79,80.72 36.89,80.82 36.89,80.98 36.99,81.08 37.44,81.08 46.07,72.44 46.07,70.66 47.04,69.7 v12(47.04,68.78)
  IN3 w0.06: v12(47.04,68.78) 46.94,68.78 46.56,68.41 v8(46.28,68.41)
  IN3 w0.064: v1(26.99,79.27) 27.38,79.27 v12(27.53,79.12) v11(27.53,78.72) 28.37,77.88 31.67,77.88 31.75,77.8 31.75,76.68 31.82,76.61 32,76.61 32.08,76.68 32.08,77.01 32.15,77.09 32.66,77.09 32.78,76.98 32.78,76.04 v8(33.01,75.81)
  IN4 w0.064: v11(27.53,78.72) 27.53,78.67 28.09,78.11 28.09,74.68 29.5,73.27 30.39,73.27 30.6,73.05 31.11,73.05 31.37,73.31 v8(31.51,73.31)
M_0_CA7: length 45.7
  IN2 w0.089: v12(27.5,78.21) 27.86,77.85 27.86,76.35 27.35,75.85 27.35,73.56 27.45,73.46 27.62,73.46 27.72,73.56 27.72,74.09 27.82,74.19 27.97,74.19 28.08,74.09 28.08,73.56 28.18,73.46 28.33,73.46 28.43,73.56 28.43,74.09 28.53,74.19 28.69,74.19 28.79,74.09 28.79,73.56 28.89,73.46 29.04,73.46 29.14,73.56 29.14,74.09 29.24,74.19 29.4,74.19 29.5,74.09 29.5,73.58 29.6,73.48 29.74,73.48 29.84,73.58 29.84,74.17 29.94,74.27 30.15,74.27 30.6,74.73 30.6,75.46 30.81,75.67 39.04,75.67 42.97,71.73 42.97,70.94 v12(43.25,70.66)
  IN3 w0.06: v12(43.25,70.66) 43.25,70.54 43.05,70.33 v11(43.05,70.31)
  IN3 w0.064: v1(26.99,78.39) 27.33,78.39 v12(27.5,78.21) v11(27.5,77.8) 27.58,77.8 27.73,77.65 31.19,77.65 31.52,77.32 31.52,76.15 31.59,76.07 31.92,76.07 32.51,76.66 v8(32.51,76.81)
  IN4 w0.06: v11(43.05,70.31) 43.2,70.31 43.81,69.7 43.81,69.45 44.04,69.22 v8(44.27,69.22)
  IN4 w0.064: v11(27.5,77.8) 27.58,77.8 27.89,77.5 27.89,74.58 29.42,73.04 30.27,73.04 v8(30.51,72.81)
M_0_CA8: length 46.8
  IN2 w0.089: v12(47.22,68.05) 47.42,68.25 47.42,69.72 46.33,70.82 46.33,72.57 37.56,81.33 28.17,81.33 26.87,80.04 26.87,78 v12(27.5,77.37)
  IN3 w0.06: v12(47.22,68.05) 46.86,68.41 v8(46.85,68.41)
  IN3 w0.064: v1(26.99,77.5) 27.38,77.5 v12(27.5,77.37) v11(27.5,76.96) 27.84,76.96 28.29,77.42 31.04,77.42 31.26,77.19 31.26,75.95 31.39,75.82 32.15,75.82 32.51,76.17 v8(32.51,76.31)
  IN4 w0.064: v8(31.01,72.81) 30.81,72.81 30.55,72.54 29.59,72.54 27.68,74.45 27.68,76.89 27.61,76.96 v11(27.5,76.96)
M_0_CA9: length 45.2
  IN2 w0.089: v12(44.9,68.12) 44.55,68.12 44.07,68.61 44.07,69.55 44.19,69.67 44.19,70.03 43.91,70.31 43.1,70.31 42.72,70.69 42.72,71.6 38.91,75.41 31.01,75.41 30.86,75.26 30.86,74.6 30.1,73.84 30.1,72.87 29.99,72.77 28.2,72.77 28.1,72.87 28.1,73.03 28,73.13 27.85,73.13 27.75,73.03 27.75,72.87 27.64,72.77 27.2,72.77 27.1,72.87 27.1,76.13 v12(27.5,76.53)
  IN3 w0.06: v12(44.9,68.12) 45.26,67.77 45.65,67.77 v8(45.72,67.84)
  IN3 w0.064: v8(32.51,75.81) 32.51,75.59 32.43,75.52 31.09,75.52 31.01,75.59 31.01,76.89 30.71,77.19 29.64,77.19 28.57,76.13 v11(27.43,76.13) 27.5,76.2 v12(27.5,76.53) 27.43,76.61 v1(26.99,76.61)
  IN4 w0.06: v8(31.51,72.81) 31.42,72.81 31.19,72.57 30.91,72.57 30.76,72.42 30.76,72.21 30.6,72.06
  IN4 w0.064: v11(27.43,76.13) 27.48,76.07 27.48,74.3 29.71,72.06 30.6,72.06
M_0_CKE0: length 35.8
  IN2 w0.064: v12(41.42,70.59) 41.42,67.11 41.35,67.03 41.14,67.03 41.07,67.11 41.07,67.69 40.99,67.77 40.81,67.77 40.73,67.69 40.73,67.11 40.66,67.03 40.49,67.03 40.41,67.11 40.41,67.69 40.34,67.77 40.17,67.77 40.09,67.69 40.09,67.11 40.01,67.03 39.85,67.03 39.77,67.11 39.77,67.69 39.7,67.77 39.53,67.77 39.46,67.69 39.46,67.11 39.38,67.03 39.21,67.03 39.14,67.11 39.14,67.69 39.06,67.77 38.9,67.77 38.82,67.69 38.82,67.11 38.74,67.03 38.58,67.03 38.5,67.11 38.5,67.69 38.43,67.77 38.26,67.77 38.19,67.69 38.19,67.11 38.11,67.03 37.94,67.03 37.87,67.11 37.87,67.69 37.79,67.77 37.63,67.77 37.55,67.69 37.55,67.11 37.47,67.03 37.31,67.03 37.23,67.11 37.23,67.69 37.16,67.77 36.99,67.77 36.92,67.69 36.92,67.11 36.84,67.03 36.67,67.03 36.6,67.11 36.6,67.69 36.52,67.77 36.36,67.77 36.28,67.69 36.28,67.11 36.2,67.03 36.04,67.03 35.96,67.11 35.96,67.69 35.89,67.77 35.72,67.77 35.65,67.69 35.65,67.11 35.57,67.03 35.4,67.03 35.33,67.11 35.33,67.69 35.25,67.77 35.09,67.77 35.01,67.69 35.01,67.11 34.93,67.03 34.77,67.03 34.69,67.11 34.69,71.99 33.63,73.05 v12(33.63,73.28)
  IN3 w0.06: v12(33.63,73.28) 32.58,73.28 32.56,73.31 31.98,73.31 31.01,74.27 v8(31.01,74.31) ; v11(41.83,70.59) 41.56,70.59
  IN3 w0.064: 41.56,70.59 v12(41.42,70.59)
  IN4 w0.06: v8(43.95,70.1) 43.23,70.82 42.26,70.82 42.14,70.69
  IN4 w0.064: 42.14,70.69 42.03,70.59 v11(41.83,70.59)
M_0_CKE1: length 35.7
  IN2 w0.064: v12(42.36,71.3) 42.36,71.53 41.38,72.51 41.28,72.51 40.42,71.65 40.31,71.65 40.19,71.77 40.19,71.87 41.05,72.73 41.05,72.84 40.94,72.96 40.83,72.96 39.97,72.1 39.86,72.1 39.75,72.22 39.75,72.32 40.6,73.18 40.6,73.29 40.49,73.41 40.38,73.41 39.52,72.55 39.41,72.55 39.3,72.67 39.3,72.77 40.15,73.63 40.15,73.74 40.04,73.85 39.93,73.85 39.07,73 38.96,73 38.85,73.11 38.85,73.22 39.7,74.08 39.7,74.19 39.57,74.32 39.47,74.32 39.27,74.12 39.06,74.12 38.76,74.42 38.76,75.08 38.71,75.13 38.53,75.13 38.44,75.04 38.44,74.35 38.36,74.27 38.19,74.27 38.12,74.35 38.12,75.06 38.04,75.13 37.88,75.13 37.8,75.06 37.8,74.09 37.72,74.02 37.56,74.02 37.48,74.09 37.48,75.06 37.41,75.13 37.24,75.13 37.17,75.06 37.17,74.09 37.09,74.02 36.92,74.02 36.85,74.09 36.85,75.06 36.77,75.13 36.61,75.13 36.53,75.06 36.53,74.09 36.45,74.02 36.29,74.02 36.21,74.09 36.21,75.06 36.14,75.13 35.97,75.13 35.9,75.06 35.9,74.02 35.82,73.94 35.65,73.94 35.58,74.02 35.58,75.06 35.5,75.13 34.46,75.13 34.34,75.01 v12(34.34,74.09)
  IN3 w0.06: v11(42.77,71.3) v12(42.36,71.3) ; v12(34.34,74.09) 34.24,74.19 34.24,75.9 34.01,76.13 v8(34.01,76.31)
  IN4 w0.06: v8(44.27,71.48) 43.23,71.48 43.05,71.3 v11(42.77,71.3)
