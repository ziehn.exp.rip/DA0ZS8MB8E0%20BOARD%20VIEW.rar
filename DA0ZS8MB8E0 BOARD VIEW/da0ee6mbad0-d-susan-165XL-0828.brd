# Allegro board da0ee6mbad0-d-susan-165XL-0828.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
SLP_S3#_EN: length 2.8
  BOTTOM w0.114: PR44.2 PR45.1 19.3,49.09 v13(19.9,49.69) 19.9,50.06 19.81,50.16 PU2.3
SLP_S4#: length 115.8
  TOP w0.114: v5(57.07,78.28) 57.32,78.03 57.44,78.03 R61.2 57.46,77.79 57.3,77.62 57.3,77.04 57.67,76.67 v13(57.78,76.67) ; v5(115.03,65.33) 115.08,65.28 R173.1
  IN2 w0.064: v12(56.18,77.22) 56.18,77.5 55.95,77.73 55.95,77.98 56.26,78.28 v5(57.07,78.28) 57.08,78.3 57.08,78.6 56.26,79.43 v4(52.73,79.43) ; v12(79.91,67.64) 79.91,68.18 80.16,68.43 81.23,68.43 84.36,71.57 85.5,71.57 85.86,71.92 91.51,71.92 91.62,72.04 94.12,72.04 97.2,68.96 97.2,68.39 99.33,66.27 104.97,66.27 105.81,65.43 109.47,65.43 109.7,65.66 111.52,65.66 112.22,66.36 114.26,66.36 115.03,65.58 v5(115.03,65.33)
  IN3 w0.06: v8(54.21,69.54) 54.21,69.82 53.84,70.18 53.84,71.38 53.97,71.5 53.97,71.78
  IN3 w0.064: v12(56.18,77.22) 56.18,76.53 56.03,76.38 55.67,76.38 55.11,75.82 55.11,74.12 54,73 54,71.97 53.97,71.94 53.97,71.78 ; v4(52.73,79.43) 52.73,79.68 54.03,80.98 66.92,80.98 67.86,80.04 80.76,80.04 81.8,79 83,79 84.2,77.8 84.2,76.48 83.65,75.92 83.65,71.89 81.76,70 80.11,70 79.98,70.13 79.35,70.13 78.74,69.52 78.74,68.28 78.84,68.18 79.37,68.18 v12(79.91,67.64) 79.91,66.22 v11(79.96,66.17)
  IN4 w0.06: v8(84.08,63.95) 83.88,64.15 81.98,64.15 81.56,64.57 81.35,64.57
  IN4 w0.064: v11(79.96,66.17) 79.96,65.41 80.79,64.57 81.35,64.57
SOC_GPIO_S5_23: length 13.3
  IN2 w0.064: v5(53.87,77.88) 53.87,77.37 55.06,76.18 57.02,76.18 v12(57.68,76.84)
  IN3 w0.06: v8(55.06,69.82) 55.06,70.23 55.6,70.77 55.6,71.46 55.92,71.78
  IN3 w0.064: 55.92,71.78 55.93,71.79 55.93,72.32 55.78,72.48 55.78,72.65 55.75,72.67 55.75,73.69 55.83,73.76 55.83,74.32 56.22,74.72 56.22,74.94 57.15,75.87 57.15,76.3 v12(57.68,76.84)
SOC_GPIO_S5_24: length 12.4
  IN2 w0.064: v5(54.63,77.88) 54.63,76.86 55.17,76.33 56.66,76.33 v12(57.17,76.84)
  IN3 w0.06: v8(54.77,69.54) 54.77,69.92 54.89,70.03 54.89,70.23 55.39,70.74 55.39,71.46 55.71,71.78
  IN3 w0.064: 55.71,71.78 55.78,71.85 55.78,72.26 55.62,72.42 55.62,72.49 55.6,72.51 55.6,73.75 55.67,73.83 55.67,74.45 56.05,74.83 56.05,75.01 56.99,75.95 56.99,76.66 v12(57.17,76.84)
SOC_GPIO_S5_25: length 8.6
  IN2 w0.064: v12(55.32,76.76) 55.09,76.99 55.09,77.62 v5(55.34,77.88)
  IN3 w0.064: v12(55.32,76.76) 55.32,76.66 v11(55.04,76.38)
  IN4 w0.06: 55.04,75.04 55.04,74.76 55.37,74.43 55.37,72.22 55.14,71.99 55.14,71.79 55.29,71.64 55.29,71.47 55.14,71.32 55.14,71.15 55.27,71.02 55.27,70.74 v8(55.34,70.67)
  IN4 w0.064: 55.04,75.04 55.65,75.64
  IN4 w0.127: 55.65,75.64 55.65,76 55.27,76.38 v11(55.04,76.38)
SOC_GPIO_S5_26: length 9
  TOP w0.114: v5(56.21,77.88) 56.21,77.84 R54.2
  IN2 w0.064: v12(58.19,76.86) 57.17,77.88 v5(56.21,77.88)
  IN3 w0.064: v11(57.25,74.6) 57.1,74.75 57.1,75.54 57.3,75.74 57.3,75.97 v12(58.19,76.86)
  IN4 w0.06: v11(57.25,74.6) 57.17,74.53 57.17,73.36 55.75,71.93 55.75,71.65 v8(55.62,71.52)
SOC_PWRBTN#: length 38
  IN3 w0.064: v11(80.92,76.13) 80.67,76.38 79.94,76.38 79.42,76.9 77.54,76.9 76.2,78.23 65.86,78.23 64.98,79.11 57.39,79.11 56.7,78.42 54.92,78.42 54.44,77.94 54.44,77.43 54.31,77.3 54.31,76.97 53.8,76.46 53.8,74.52 v11(54.12,74.19)
  IN4 w0.06: v8(53.36,71.52) 53.48,71.65 53.48,71.78 54.06,72.35 54.06,74.13 v11(54.12,74.19)
  IN4 w0.064: v1(83.28,76.96) 82.47,76.15 80.95,76.15 v11(80.92,76.13)
SOC_PWRBTN#_R: length 26.8
  IN2 w0.064: v4(79.68,60.22) 79.8,60.35 79.8,62.78 80.03,63.02 80.03,65.03 79.58,65.48 78.66,65.48 78.41,65.73 78.41,67.17 78.64,67.39 v4(78.76,67.39)
  IN3 w0.064: v4(78.76,67.39) 78.18,67.97 78.18,69.85 80.23,71.9 82.82,71.9 83.12,72.2 83.12,77.69 v1(83.23,77.8) ; v4(79.68,60.22) v11(80.04,60.59)
  IN4 w0.07: 81.33,60.73 81.51,60.73 82.06,61.29 82.52,61.29 82.78,61.55 v8(82.88,61.55)
  IN4 w0.127: v11(80.04,60.59) 80.18,60.73 81.33,60.73
SOC_RTEST#: length 42.4
  TOP w0.114: v9(69.39,67.21) 69.39,61.09 71.78,58.7 77.57,58.7 v13(77.85,58.98) 78.13,58.7 79.27,58.7 79.45,58.52 79.45,57.86 79.56,57.75 PR3.1
  IN2 w0.064: v5(63.42,75.52) 63.42,75.53 v4(63.11,75.85)
  IN3 w0.06: v7(57.73,70.95) 58.42,71.63 58.42,71.78
  IN3 w0.064: 58.42,71.78 58.42,72.18 59.34,73.1 60.91,73.1 62.94,75.13 62.94,75.33 v1(62.96,75.35) 62.96,75.69 v4(63.11,75.85)
  IN4 w0.06: v7(57.73,70.95) 57.6,70.95 57.4,70.75 57.24,70.75 57.04,70.95 v8(57.04,71.24)
  BOTTOM w0.114: v1(62.96,75.35) 63.7,75.35 R324.2 66.74,75.43 67.26,74.91 67.26,71.99 69.39,69.85 v13(69.39,68.94) v9(69.39,67.21)
SOC_RTEST#_R: length 6.3
  IN2 w0.064: v4(80.72,59.08) 80.92,58.88 v5(80.92,58.59)
  IN3 w0.06: v8(84.08,63.15) 84.08,62.95 83.69,62.56 83.69,62.33 82.3,60.95 82.3,60.26
  IN3 w0.064: 82.3,60.26 81.12,59.08 v4(80.72,59.08)
SOC_SPI_CLK: length 28.7
  IN2 w0.064: v5(73.68,67.73) 73.43,67.47 73.06,67.47 72.93,67.6 72.93,67.96 72.63,68.26 72.49,68.26 72.13,68.62 72.13,69.37 71.37,70.13 70.94,70.13 v5(70.89,70.08) 70.89,70.16 70.22,70.82 66.9,70.82 66.16,71.57 66.16,72.69 65.05,73.8 64.45,73.8 64.06,74.19 62.77,74.19 62.57,74.39 59.19,74.39 59.03,74.22 57.68,74.22 57.18,73.72 56.7,73.72 56.58,73.84 54.1,73.84 53.18,72.92 52.7,72.92 v12(52.4,72.62)
  IN3 w0.064: v11(52.32,72.22) 52.32,72.22 52.32,72.54 v12(52.4,72.62)
  IN4 w0.06: v8(51.94,70.67) 51.94,70.95 52.14,71.15 52.14,71.32 51.99,71.47 51.99,71.64 52.32,71.97 v11(52.32,72.22)
SOC_SPI_CS#: length 26.4
  TOP w0.114: R96.2 70.27,70.36 v5(70.3,70.36)
  IN2 w0.064: v5(72.68,67.73) 71.9,68.5 71.9,69.34 71.68,69.57 70.94,69.57 70.51,70 70.51,70.16 v5(70.3,70.36) 70.02,70.65 66.83,70.65 65.98,71.5 65.98,72.61 64.97,73.62 64.37,73.62 63.99,74.01 62.7,74.01 62.5,74.21 59.42,74.21 59.25,74.04 57.75,74.04 57.25,73.54 56.62,73.54 56.5,73.66 54.17,73.66 53.11,72.59 v12(52.93,72.59)
  IN3 w0.064: v11(52.67,72.24) 52.67,72.34 v12(52.93,72.59)
  IN4 w0.06: v8(52.19,71.56) 52.25,71.56 52.67,71.98 v11(52.67,72.24)
SOC_SPI_MISO: length 28.7
  TOP w0.114: v5(68.55,70.4) 68.55,70.38 68.97,69.96 R95.2
  IN2 w0.064: v12(52.09,71.86) 52.09,72.11 52.19,72.21 53.01,72.21 53.06,72.27 53.25,72.46 53.25,72.46 54.28,73.48 56.43,73.48 56.55,73.36 57.33,73.36 57.83,73.86 59.37,73.86 59.53,74.03 62.43,74.03 62.62,73.83 63.91,73.83 64.3,73.45 64.89,73.45 65.8,72.54 65.8,71.42 66.76,70.46 68.49,70.46 v5(68.55,70.4) 68.56,70.38 69.67,70.38 72.83,67.23 v5(73.18,67.23)
  IN3 w0.06: 52.09,71.78 52.09,71.5 51.94,71.35 v8(51.94,69.54)
  IN3 w0.064: v12(52.09,71.86) 52.09,71.78
SOC_SPI_MOSI: length 27.6
  IN2 w0.064: v12(52.75,71.83) 53.65,71.83 54.01,72.19 54.01,72.96 54.35,73.31 56.36,73.31 56.48,73.19 57.43,73.19 57.91,73.66 59.42,73.66 59.61,73.85 62.35,73.85 62.55,73.66 63.82,73.66 64.21,73.27 64.82,73.27 65.62,72.46 65.62,71.35 66.76,70.21 v5(68.12,70.21) 68.18,70.15 69.65,70.15 72.84,66.96 73.96,66.96 74.18,67.18 v5(74.18,67.23)
  IN3 w0.06: 52.71,71.78 52.23,71.3 v8(52.23,70.95)
  IN3 w0.064: 52.71,71.78 v12(52.75,71.83)
SOC_USB_OC#: length 8.8
  IN4 w0.06: 54,75.06 54,75.06 53.67,74.73 53.67,72.47 53.28,72.08 52.95,72.08 52.87,72.01 52.87,71.15 52.99,71.04 52.99,71.03 53.07,70.95 v8(53.07,70.67)
  IN4 w0.127: v1(53.11,77.75) 53.49,77.75 54.48,76.76 54.48,75.54 54,75.06
SOC_XTAL_IN: length 9.6
  IN3 w0.064: v8(57.89,63.03) 58,63.15 60.58,63.15 60.79,62.94 63.24,62.94 v1(63.27,62.97)
  BOTTOM w0.114: Y4.1 65.68,62.76 64.27,62.76 64.26,62.78 C293.1 63.5,62.78 R326.2
SOC_XTAL_OUT: length 8
  IN3 w0.064: v1(63.29,62.31) 62.98,62.62 60.62,62.62 60.42,62.82 57.67,62.82 v8(57.6,62.75)
  BOTTOM w0.114: R326.1 63.73,62.17 C294.1 64.27,61.86 64.47,61.66 Y4.3
SPI_CLK: length 52.8
  TOP w0.114: v5(71.8,71.32) 71.7,71.32 71.5,71.53 v13(71.27,71.53) 70.76,71.02 R97.2 ; v5(74.29,65.3) 74.31,65.29 C88.1 74.7,67.21 U8.A1
  IN2 w0.064: v5(71.8,71.32) 72.72,71.32 74.6,69.45 74.6,69.04 73.89,68.33 73.89,68.17 74.58,67.48 74.58,65.6 v5(74.29,65.3) 73.64,64.66 73.64,61.38 73.93,61.1 73.93,54.82 74.24,54.51 74.24,52.88 74.42,52.71 74.42,46.23 72.23,44.04 72.23,40.03 71.8,39.6 65.78,39.6 64.72,40.67 63.4,40.67 v9(62.89,40.16)
  BOTTOM w0.114: v9(62.89,40.16) 62.51,39.78 U30.6
SPI_CS#: length 58.3
  TOP w0.114: R96.1 69.94,70.81 70.57,71.44 70.57,71.62 71.02,72.06 v5(71.02,72.11) ; U8.D1 75.07,68.73 v5(75.08,68.73) ; v9(61.85,43.03) 61.74,43.13 v13(60.86,43.13) 60.47,42.75 R72.1
  IN2 w0.064: v9(61.85,43.03) 61.85,42.39 62.25,41.99 62.25,39.75 62.94,39.07 71.92,39.07 72.69,39.84 72.69,43.85 74.9,46.07 74.9,53.19 74.72,53.37 74.72,54.67 74.39,55.01 74.39,61.3 74.1,61.59 74.1,63.41 75.16,64.47 75.16,68.66 v5(75.08,68.73) 75.05,68.76 75.05,69.66 72.84,71.88 71.25,71.88 v5(71.02,72.11)
  BOTTOM w0.114: v9(61.85,43.03) 60.4,43.03 59.97,43.46 U30.1
SPI_MISO: length 55.2
  TOP w0.114: R95.1 68.98,70.97 69.64,71.63 v13(69.82,71.63) 70.25,71.63 70.66,72.04 v5(70.66,72.11)
  IN2 w0.064: v9(62.46,43.05) 62.46,39.98 63.19,39.24 71.88,39.24 72.53,39.9 72.53,43.91 74.75,46.13 74.75,53.06 74.57,53.24 74.57,54.61 74.23,54.94 74.23,61.24 73.95,61.52 73.95,63.59 74.95,64.59 74.95,67.96 v5(74.68,68.23) 74.68,68.69 74.9,68.91 74.9,69.6 72.77,71.72 71.05,71.72 v5(70.66,72.11)
  BOTTOM w0.114: v9(62.46,43.05) 62.46,43.13 62.13,43.46 61.36,43.46 61.24,43.59 U30.2
SPI_MOSI: length 52.9
  TOP w0.114: v5(70.3,72.11) 69.52,72.11 69.44,72.04 68.86,72.04 v13(68.55,71.73) 68.55,71.26 R92.2
  IN2 w0.064: v5(70.3,72.11) 70.84,71.57 72.7,71.57 74.75,69.52 74.75,68.98 74.43,68.66 74.43,67.98 v5(74.68,67.73) 74.8,67.61 74.8,64.85 73.8,63.84 73.8,61.46 74.08,61.17 74.08,54.88 74.39,54.57 74.39,53.11 74.6,52.91 74.6,46.19 72.38,43.98 72.38,39.96 71.84,39.42 64.26,39.42 v9(63.52,40.16)
  BOTTOM w0.114: v9(63.52,40.16) 63.52,37.95 63.78,37.7 U30.5
SPI_PWR_EN: length 6.6
  TOP w0.254: D1.1 D2.1 61.98,45.44 63.65,45.44 63.9,45.7 65.74,45.7 U5.A1
SPK_LN: length 20.3
  IN2 w0.762: v14(131.54,76.99) 130.03,78.5 118.92,78.5 117.88,77.46 117.86,77.46 115.34,74.93 114.42,74.93 113.74,75.62 v9(113.59,75.62)
SPK_LP: length 22.2
  IN2 w0.762: v9(114.78,75.85) 114.78,76.56 115.25,77.03 115.28,77.03 118.28,80.02 130.72,80.02 133.32,77.42 v14(133.32,76.99)
SPK_RN: length 15.3
  IN2 w0.762: v9(113.38,74.7) 114.14,73.94 116.52,73.94 119.55,76.98 v14(127.07,76.98)
SPK_RP: length 18.3
  IN2 w0.762: v14(128.88,76.99) 128.88,76.35 127.97,75.45 120.2,75.45 117.52,72.77 113.99,72.77 v9(113.08,73.69)
SRT_CRST#: length 10.1
  TOP w0.114: v5(61.82,75.39) 61.82,75.39 CN1.38
  IN2 w0.064: v12(61.62,74.98) 61.82,75.19 v5(61.82,75.39)
  IN3 w0.06: 58.11,71.78 58.11,71.55 57.9,71.34 57.79,71.34 56.84,70.39 v8(56.75,70.39)
  IN3 w0.064: v1(62.15,74.98) v12(61.62,74.98) 61.62,74.42 60.83,73.64 59.48,73.64 58.11,72.26 58.11,71.78
  BOTTOM w0.114: R325.2 63.17,74.45 62.93,74.69 C290.1 62.44,74.69 v1(62.15,74.98)
STM_12M_IN: length 7.1
  TOP w0.114: Y1.3 101.24,39.27 99.97,39.27 99.72,39.02 99.72,38.38 99.45,38.11 C104.1 99.22,38.11 98.96,38.38 98.96,39.65 98.31,40.3 U10.5
STM_12M_OUT: length 1.3
  TOP w0.114: U10.6 99.3,40.8 R152.2
STM_12M_OUT_R: length 2.5
  TOP w0.114: R152.1 C107.1 100.52,40.44 Y1.1
SUS_CLK_GPS: length 101.1
  IN2 w0.064: v12(57.48,69.29) 57.07,69.7 57.07,70.31 57.49,70.73 60.52,70.73 60.61,70.82 62.02,70.82 62.37,70.47 63.01,70.47 65.71,67.78 68.16,67.78 68.46,67.48 68.46,66.82 69,66.28 69.89,66.28 70.51,65.66 70.51,65.36 71.13,64.74 71.13,61.74 70.84,61.45 70.84,59.92 70,59.08 70,53.87 70.51,53.37 70.51,51.6 70.24,51.33 69.86,51.33 69.57,51.63 68.82,51.63 65.15,47.96 63.43,47.96 59.89,44.41 59.89,42.9 55.19,38.2 43.13,38.2 40.46,35.52 40.46,34.51 37.96,32.01 34.85,32.01 28.44,25.6 28.44,22.66 26.34,20.55 26.34,19.81 v4(26.03,19.51)
  IN3 w0.06: v8(55.62,69.82) 55.62,69.47 55.78,69.32 55.97,69.32 56.1,69.46 56.27,69.46 56.41,69.32 56.56,69.32 56.71,69.47 56.84,69.47 57.02,69.29 v12(57.48,69.29)
  IN3 w0.064: v4(26.03,19.51) 26.39,19.15 28.35,19.15 v1(29.87,17.64)
SUS_CLK_WLAN: length 132.6
  IN2 w0.064: v4(87.02,77.32) 87.02,76.19 86.53,75.71 86.04,75.71 85.51,76.24 82.37,76.24 81.5,77.11 80.88,77.11 v4(80.87,77.12)
  IN3 w0.064: v11(56.79,79.4) 57.05,79.66 65.22,79.66 66.11,78.77 76.43,78.77 77.76,77.43 79.69,77.43 80.18,76.94 80.59,76.94 80.79,77.14 80.84,77.14 v4(80.87,77.12) ; v1(155.76,79.92) 155.55,80.13 153.26,80.13 152.55,80.84 150.45,80.84 149.29,79.67 147.74,79.67 139.15,71.08 131.91,71.08 130.86,70.03 127.98,70.03 125.31,67.36 125.31,66.32 121.76,62.77 117.8,62.77 116.55,64.02 116.55,68.91 114.6,70.87 113.13,70.87 112.57,70.31 110.81,70.31 110.5,70 109.52,70 103.17,76.35 100.1,76.35 98.96,75.21 97.83,75.21 97.36,75.68 87.95,75.68 87.02,76.61 v4(87.02,77.32)
  IN4 w0.06: 58.44,75.21 58.44,75.16 58.24,74.96 58.24,74.02 56.1,71.88 56.1,71.15 55.9,70.95 v8(55.9,70.67)
  IN4 w0.064: v11(56.79,79.4) 57.05,79.15 57.86,79.15 58.44,78.56 58.44,75.21
SUS_PWRDNACK: length 19.5
  IN3 w0.064: v11(79.88,69.88) 79.94,69.81 81.84,69.81 83.82,71.79 83.82,75.84 84.38,76.4 84.38,77.22 v1(84.68,77.52)
  IN4 w0.06: 81.35,65.28 81.89,64.75 82.19,64.75 82.39,64.55 82.68,64.55 v8(82.88,64.35)
  IN4 w0.064: v11(79.88,69.88) 80.31,69.45 80.31,69.27 80.69,68.89 80.69,65.94 81.35,65.28
  BOTTOM w0.114: v13(85.11,76.33) 85.19,76.4 PR95.1 85,77.08 84.68,77.4 v1(84.68,77.52)
SUS_PWRDOWNACK: length 45
  IN3 w0.06: 53.13,71.78 53.13,70.16 v8(53.07,70.1)
  IN3 w0.064: 53.13,71.78 53.13,72.33 53.27,72.47 53.27,75.68 52.02,76.92 52.02,77.42 52.12,77.52 52.12,79.33 53.95,81.16 66.99,81.16 67.92,80.23 80.82,80.23 81.87,79.17 83.82,79.17 v1(84.68,78.31)
  BOTTOM w0.114: PR95.2 85.07,77.92 v1(84.68,78.31)
SVID_ALERT#: length 6.2
  IN4 w0.06: 52.6,75.21 52.6,74.58 53.11,74.07 53.11,72.92 52.85,72.67 52.24,72.67 51.74,72.17 51.74,71.79 51.86,71.67 51.86,71.44 51.66,71.24 v8(51.66,70.95)
  IN4 w0.064: v1(52.65,75.85) 52.6,75.8 52.6,75.21 52.6,75.21
SVID_ALERT#_R: length 60.1
  IN3 w0.06: 81.51,60.61 81.73,60.61 81.89,60.76 81.89,61.01 82.42,61.55 82.42,61.83 82.74,62.15 83.08,62.15 v8(83.28,62.35)
  IN3 w0.064: v1(52.73,77.17) 52.78,77.22 52.78,78.46 54.63,80.32 66.16,80.32 67.08,79.4 77.26,79.4 78.91,77.75 80.25,77.75 80.38,77.88 v1(80.57,77.88) 81.2,77.88 82.13,76.95 82.13,75.37 81.73,74.98 80.3,74.98 80.06,74.74 80.06,73.08 77.07,70.1 76.34,70.1 75.97,69.72 75.97,64.99 76.8,64.16 77.49,64.16 78.6,63.05 78.6,61.8 79.22,61.19 80.31,61.19 80.9,60.61 81.51,60.61
  BOTTOM w0.114: PR51.2 v1(52.73,77.17)
SVID_CLK: length 5.5
  IN4 w0.06: 52.03,75.21 52.03,74.34 52.46,73.9 52.46,73.7 52.85,73.31 52.85,73.13 52.69,72.96 52.26,72.96 51.62,72.33 51.62,71.56 v8(51.66,71.52)
  IN4 w0.064: 52.03,75.21 52.03,75.78 v1(51.97,75.85)
SVID_CLK_R: length 61.9
  IN3 w0.06: 82.04,60.91 82.04,60.73 81.56,60.25 80.84,60.25 80.82,60.28
  IN3 w0.064: 82.04,60.91 82.88,61.75 v8(82.88,61.95) ; 80.82,60.28 80.77,60.28 80.18,60.86 78.76,60.86 78.12,61.5 78.12,63.03 77.3,63.84 76.67,63.84 75.65,64.86 75.65,70.11 75.96,70.42 76.94,70.42 79.72,73.19 79.72,74.85 80.17,75.29 81.6,75.29 81.81,75.5 81.81,76.81 81.12,77.5 80.46,77.5 80.36,77.4 v1(80.16,77.4) ; v1(80.01,78.41) 79.73,78.41 78.42,79.72 67.21,79.72 66.28,80.65 54.45,80.65 52.45,78.64 52.45,77.32 v1(52.3,77.17)
  BOTTOM w0.114: PR50.2 51.84,76.86 52.14,77.17 v1(52.3,77.17) ; v1(80.01,78.41) 79.94,78.41 79.65,78.12 PR83.2 79.65,77.87 80.12,77.4 v1(80.16,77.4)
SVID_DATA: length 6
  IN4 w0.06: v8(51.94,71.88) 51.94,72.15 52.24,72.45 53.11,72.45 53.29,72.63 53.29,75.21
  IN4 w0.064: v1(53.49,75.85) 53.29,75.64 53.29,75.21
  BOTTOM w0.114: R303.1 PR52.1
SVID_DATA_R: length 29.1
  IN3 w0.064: v1(77.85,77.88) 76.64,79.08 66.95,79.08 66.04,79.99 54.81,79.99 53.11,78.28 53.11,77.22 v1(53.16,77.17)
  BOTTOM w0.114: PR52.2 53.62,76.86 53.31,77.17 v1(53.16,77.17) ; PR81.1 PR80.2
SYS_SHDN#: length 3.9
  TOP w0.114: R87.1 C79.1 D3.1 65.4,82.34 SW4.5
SYSTHERM_0: length 96.6
  TOP w0.114: v5(85.82,68.43) 85.58,68.67 C97.2 84.92,68.67 84.44,69.15 PR54.2
  IN1 w0.064: v5(100.33,67.46) v5(100.33,64.44)
  IN2 w0.064: v5(100.33,67.46) 100.45,67.34 105.56,67.34 106.38,66.51 109.01,66.51 109.66,67.17 113.2,67.17 118,67.17 121.33,63.83 121.33,62.31 121.48,62.16 121.87,62.16 122.04,62.33 122.04,63.22 122.22,63.4 122.63,63.4 122.88,63.15 124.55,63.15 125.38,63.98 125.38,67.46 126.43,68.51 126.43,71.5 127.88,72.95 140.8,72.95 142.07,74.22 142.07,76.4 138.69,79.78 v9(138.58,79.78) ; v5(85.82,68.43) 85.49,68.76 v4(85.49,68.84) 85.49,69.32 86.59,70.41 87.91,70.41 88.21,70.72 93.9,70.72 95.15,69.47 95.15,65.89 96.69,64.34 100.23,64.34 v5(100.33,64.44)
  IN3 w0.064: v11(84.91,68.4) 85.34,68.84 v4(85.49,68.84)
  IN4 w0.06: 84.73,65.99 84.73,65.41 84.68,65.36 84.68,64.26 84.48,64.06 v8(84.48,63.95)
  IN4 w0.07: 84.73,66.25 84.73,65.99
  IN4 w0.127: v11(84.91,68.4) 84.91,67.59 84.7,67.38 84.7,66.27 84.73,66.25
  BOTTOM w0.114: PR55.1 137.28,78.74 138.33,79.78 v9(138.58,79.78)
SYSTHERM_1: length 53.6
  TOP w0.114: PR114.2 C95.2 82.8,69.66 v5(82.8,68.73)
  IN2 w0.064: v4(83.23,68.2) 82.8,68.63 v5(82.8,68.73)
  IN3 w0.064: v11(89.56,51.21) 89.56,53.56 90.13,54.13 91.84,54.13 97.08,59.36 97.08,63.38 96.57,63.89 96.57,69.65 94.51,71.71 91.64,71.71 90.41,70.47 89.39,70.47 88.41,69.49 84.27,69.49 83.23,68.45 v4(83.23,68.2) 83.23,68.07 83.49,67.82 v11(83.51,67.82)
  IN4 w0.06: 83.49,65.74 83.48,65.73 83.48,64.64 83.57,64.55 83.88,64.55 v1(84.08,64.35)
  IN4 w0.064: v11(89.56,51.21) 89.51,51.21 89.2,50.9 89.2,47.25 v1(90.04,46.41)
  IN4 w0.07: 83.49,66.47 83.49,65.74
  IN4 w0.127: v11(83.51,67.82) 83.49,67.79 83.49,66.47
  BOTTOM w0.114: v1(90.04,46.41) 90.09,46.36 90.09,45.37 89.81,45.09 PR115.1
SYSTHERM_2: length 33.4
  TOP w0.114: PR107.2 83.55,69.15 v5(83.69,69.29) 83.69,69.58 C96.2 83.27,71.03 82.9,71.4 82.04,71.4 81.73,71.1 81.73,69.88 81.51,69.65 76.78,69.65 76.2,70.23 72.13,70.23 70.91,69.01 66.24,69.01 v2(64.28,70.97)
  IN1 w0.064: v2(64.28,70.97) 64.28,72.16 64.06,72.39 v5(64.06,72.75)
  IN2 w0.064: v5(64.06,72.75) 63.93,72.87 v4(63.6,72.87)
  IN2 w0.127: v4(84.12,68.05) 83.69,68.48 v5(83.69,69.29)
  IN3 w0.064: v4(63.6,72.87) 63.24,72.52 v1(62.96,72.52)
  IN3 w0.127: v11(83.82,67.62) 83.82,67.74 v4(84.12,68.05)
  IN4 w0.06: v8(84.48,64.35) 84.28,64.55 84.28,65.68 84.22,65.74
  IN4 w0.127: v11(83.82,67.62) 83.94,67.62 84.1,67.46 84.1,65.86 84.22,65.74
THERMTRIP_B: length 52.7
  TOP w0.114: Q24.6 87.29,42.97 87.46,43.14 87.46,43.8 v9(86.36,44.91)
  IN2 w0.064: v12(79.07,69.39) 79.07,69.34 79.4,69.01 79.4,68.71 79.22,68.53 78.56,68.53 78.11,68.08 78.11,64.69 78.38,64.42 79.4,64.42 79.65,64.16 79.65,63.15 79.27,62.76 v4(79.27,62.64) 78.57,61.94 78.57,58.82 79.8,57.58 79.8,54.76 83.58,50.99 83.58,46.87 85.54,44.91 v9(86.36,44.91)
  IN3 w0.06: 81.51,62 82.19,62 82.73,62.55 83.36,62.55 83.36,62.54 83.88,63.05 83.88,63.36 84.06,63.55 v8(84.08,63.55)
  IN3 w0.064: v4(79.27,62.64) 79.52,62.64 80.29,61.88 80.67,61.88 80.79,62 81.51,62 ; v11(84.63,76.53) 84.63,76.38 84.03,75.78 84.03,71.73 81.92,69.62 79.3,69.62 v12(79.07,69.39)
  IN4 w0.127: v11(84.63,76.53) 85.59,76.53 v1(86.13,77.07)
TOUCH_INT#: length 109.9
  TOP w0.114: v5(115.87,50.73) 115.08,50.73 113.84,49.48 113.84,46.23 113.41,45.8 113.41,45.44 112.99,45.02 112.8,45.02 112.8,45.52 113.29,46.01 U37.4
  IN2 w0.064: v4(66.54,76.63) 66.57,76.61 69.69,76.61 70.05,76.25 79.16,76.25 81.09,74.32 87.91,74.32 88.49,74.91 92.81,74.91 92.98,75.08 93.7,75.08 97.96,70.81 97.96,68.56 99.7,66.82 105.2,66.82 106.04,65.98 109.24,65.98 109.47,66.21 111.27,66.21 111.97,66.91 118.02,66.91 121.08,63.84 121.08,61.8 121.64,61.24 121.64,59.97 v4(121.84,59.77) ; v4(115.87,51.18) v5(115.87,50.73)
  IN3 w0.064: v4(115.87,51.18) 115.94,51.18 116.27,51.51 116.27,52.56 116.87,53.17 116.87,56.63 118.08,57.84 119.71,57.84 121.46,59.59 121.66,59.59 v4(121.84,59.77) ; v11(54.51,74.58) 54.23,74.86 54.23,76.4 54.65,76.83 54.65,77.08 55.28,77.71 55.66,77.71 v1(55.78,77.83) 56.82,77.83 57.6,78.61 64.78,78.61 66.3,77.1 66.3,76.86 66.52,76.63 v4(66.54,76.63)
  IN4 w0.06: v11(54.51,74.58) 54.78,74.3 54.78,73.71 54.48,73.41 54.48,72.43 53.84,71.79 53.84,71.15 53.64,70.95 v8(53.64,70.67)
TOUCH_INT#_C: length 14.9
  TOP w0.114: U37.5 113.29,50.52 v5(114.32,51.55)
  IN2 w0.064: v5(114.32,51.55) 115.63,51.55 v9(115.87,51.79)
  IN3 w0.064: v9(115.87,51.79) 116.02,51.94 116.02,52.54 116.72,53.23 116.72,56.69 118.02,57.99 119.65,57.99 121.35,59.69 v1(121.35,59.81)
TOUCH_RESET#: length 75
  TOP w0.114: v5(111.82,45.11) 112.79,46.08 U37.3
  IN2 w0.064: v5(111.82,45.11) 111.82,45.07 111.53,44.78 111.53,41.94 110.41,40.82 104.6,40.82 103.19,42.23 102.92,42.23 102.11,43.04 99.86,43.04 98.71,41.89 97.61,41.89 96.92,42.57 96.57,42.57 96.14,43 96.14,46.2 v4(96.08,46.25)
  IN3 w0.064: v4(96.08,46.25) 96.03,46.31 v1(95.6,46.31) 95.58,46.33 91.83,46.33 91.39,45.89 89.51,45.89 89.3,45.68 88.64,45.68 88.28,46.04 88.28,46.41 87.95,46.74 87.29,46.74 86.25,45.7 82.24,45.7 81.91,46.03 80.52,46.03 79.89,46.67 73.92,46.67 71.48,49.11 69.48,49.11 69.17,49.42 67.74,49.42 67.54,49.63 66.69,49.63 64.93,51.39 v11(64.82,51.39)
  IN4 w0.06: 56.89,54.59 56.89,54.77 55.84,55.82 55.84,56.4 55.75,56.49 55.75,56.68 v8(55.62,56.81)
  IN4 w0.064: v11(64.82,51.39) 64.61,51.39 64.38,51.62 61.98,51.62 61.38,52.22 60.46,52.22 58.42,54.27 57.08,54.27 56.89,54.45 56.89,54.59
  BOTTOM w0.114: R345.1 95.6,47.05 v1(95.6,46.31)
TOUCH_RESET#_C: length 16.8
  TOP w0.114: v5(113.43,51.55) 112.79,50.91 U37.6
  IN2 w0.064: v5(113.43,51.55) v4(112.86,51.55)
  IN3 w0.064: v1(121.35,60.31) 120.91,59.88 120.91,59.47 119.59,58.14 117.95,58.14 116.57,56.76 116.57,53.3 115.07,51.8 113.11,51.8 v4(112.86,51.55)
TP_PROXI1_POUT: length 4.2
  TOP w0.114: U10.29 90.53,41.8 90.34,41.99 90.34,42.26 90.57,42.49 90.57,44.76 TP11.1
UART_3_RXD: length 94.7
  TOP w0.114: v5(64.44,76.05) 64.44,76 64.22,75.78 CN1.32
  IN2 w0.064: v4(68.3,48.55) 67.94,48.55 63.09,43.7 61.71,43.7 61.45,43.45 61.45,41.51 60.07,40.12 60.07,39.13 60.5,38.7 60.5,38.01 60.74,37.77 63.45,37.77 64.13,38.46 72.17,38.46 73.29,39.58 73.29,43.6 75.51,45.81 75.51,46.51 76.07,47.07 76.07,53.51 75.33,54.24 75.33,54.92 75.02,55.24 75.02,61.54 74.72,61.84 74.72,62.71 75.79,63.78 75.79,69.79 73.09,72.49 71.64,72.49 71.28,72.85 70.51,72.85 70.25,73.1 70.25,75.1 69.66,75.69 67.62,75.69 67.17,75.24 65.52,75.24 64.72,76.05 v5(64.44,76.05)
  IN3 w0.06: 59.7,54.18 59.62,54.26 57.6,54.26 57.38,54.48 v11(57.17,54.48)
  IN3 w0.064: v4(68.3,48.55) 68.07,48.78 67.17,48.78 66.81,49.13 66.48,49.13 64.79,50.83 64.57,50.83 63.57,51.83 63.57,52.96 62.85,53.67 60.21,53.67 59.7,54.18
  IN4 w0.06: 57.17,54.59 57.17,54.66 55.98,55.85 55.98,56.47 55.87,56.58 55.87,57.05 v8(55.9,57.09)
  IN4 w0.07: v11(57.17,54.48) 57.17,54.59
UART_3_TXD: length 96.7
  TOP w0.114: v5(64.06,76.05) 63.82,75.82 CN1.33
  IN2 w0.064: v5(64.06,76.05) 64.3,76.3 64.72,76.3 65.6,75.41 67.12,75.41 67.56,75.85 69.75,75.85 70.41,75.19 70.41,73.2 70.61,73 71.34,73 71.7,72.64 73.15,72.64 75.95,69.84 75.95,63.63 75.49,63.17 75.49,61.88 75.17,61.56 75.17,55.3 75.49,54.99 75.49,54.31 76.22,53.57 76.22,47 75.66,46.45 75.66,45.75 73.45,43.53 73.45,39.52 72.21,38.28 66.42,38.28 65.76,37.62 60.68,37.62 60.35,37.95 60.35,38.64 59.92,39.07 59.92,40.18 61.3,41.57 61.3,43.51 61.64,43.85 63.03,43.85 68.1,48.92 68.55,48.92 v4(68.91,48.57)
  IN3 w0.06: 57.48,54.61 57.48,54.87 v11(57.17,55.17)
  IN3 w0.064: v4(68.91,48.57) 68.54,48.93 67.23,48.93 66.87,49.28 66.55,49.28 64.85,50.98 64.63,50.98 63.72,51.89 63.72,53.02 62.92,53.82 60.27,53.82 59.72,54.38 57.71,54.38 57.48,54.61
  IN4 w0.06: v8(56.19,56.81) 56.26,56.74 56.26,56.08 v11(57.17,55.17)
UART_BT_CTS: length 172.6
  IN2 w0.064: v4(163.95,79.63) 163.95,79.85 164.07,79.96 164.33,79.96 164.4,79.9 v5(164.4,79.63)
  IN3 w0.06: 50.52,54.59 50.52,55.78 49.65,56.64 49.65,57.43 49.3,57.79 49.3,58.07 49.17,58.19 49.17,58.56 49.4,58.79 v8(49.68,58.79)
  IN3 w0.064: v4(163.95,79.63) 163.95,79.81 164.11,79.96 164.31,79.96 164.49,79.79 164.49,79.2 159.1,73.81 152.81,73.81 147.32,68.33 133.45,68.33 132.39,67.27 129.15,67.27 128.06,66.19 128.06,58.04 126.08,56.06 124.1,56.06 122.75,54.71 122.75,48.01 114.3,39.55 107.25,39.55 105.93,38.23 105.93,37.45 102.71,34.24 81.81,34.24 81.62,34.05 71.46,34.05 68.98,36.53 67.89,36.53 65.5,38.91 48.73,38.91 45.52,42.13 45.52,48.5 49.37,52.35 49.81,52.35 49.93,52.48 49.93,52.71 49.81,52.83 49.81,53.42 50.52,54.13 50.52,54.59
UART_BT_CTS_C: length 7.7
  TOP w0.114: v9(162.71,79.76) 162.84,79.63 R391.1
  IN3 w0.064: v9(162.71,79.76) 162.53,79.94 162.06,79.94 161.95,79.82 161.95,79.12 160.42,77.6 159.26,77.6 158.87,77.98 158.87,78.66 159.1,78.89 159.24,78.89 v1(159.36,79.02)
UART_BT_RTS: length 170.8
  IN2 w0.064: v4(163.95,80.52) 163.95,80.25 164.07,80.14 164.31,80.14 164.4,80.23 v5(164.4,80.52)
  IN3 w0.064: v11(49.68,52.6) 49.6,52.53 49.3,52.53 45.34,48.57 45.34,42.05 48.66,38.74 65.43,38.74 67.81,36.35 68.91,36.35 71.39,33.87 81.69,33.87 81.88,34.06 102.79,34.06 106.11,37.38 106.11,38.16 107.32,39.37 114.37,39.37 122.93,47.93 122.93,54.64 124.17,55.88 126.16,55.88 128.24,57.96 128.24,66.12 129.22,67.1 132.47,67.1 133.52,68.15 147.39,68.15 152.88,73.64 159.17,73.64 164.66,79.13 164.66,79.86 164.39,80.14 164.11,80.14 163.95,80.29 v4(163.95,80.52)
  IN4 w0.06: v8(49.43,56.77) 49.35,56.69 49.35,56.13 50.06,55.42 50.06,54.94 49.84,54.73
  IN4 w0.064: 49.84,54.73 49.7,54.59 49.7,53.54 49.78,53.47 49.78,52.73 49.68,52.63 v11(49.68,52.6)
UART_BT_RTS_C: length 7.6
  TOP w0.114: R392.1 162.84,80.52 v9(162.71,80.39)
  IN3 w0.064: v9(162.71,80.39) 162.43,80.11 161.99,80.11 161.77,79.9 161.77,79.2 160.35,77.78 159.33,77.78 159.05,78.06 159.05,78.59 159.18,78.72 159.31,78.72 159.36,78.66 v1(159.36,78.12)
UART_BT_RXD: length 169.3
  IN2 w0.064: v5(164.4,82.3) 164.4,81.96 164.33,81.89 164.13,81.89 v4(163.98,82.04)
  IN3 w0.064: v4(163.98,82.04) 163.67,81.74 163.5,81.74 163.17,81.41 163.17,79.32 161.03,77.19 161.03,76.68 158.73,74.38 152.63,74.38 146.95,68.7 133.26,68.7 132.21,67.64 128.99,67.64 127.7,66.34 127.7,58.2 125.93,56.44 123.96,56.44 122.32,54.8 122.32,48.36 113.92,39.96 107.13,39.96 105.53,38.36 105.53,37.58 102.62,34.67 81.53,34.67 81.28,34.42 71.88,34.42 66.95,39.35 48.98,39.35 46.03,42.3 46.03,48.32 49.63,51.92 v11(50.03,51.92)
  IN4 w0.06: v8(49.68,56.45) 49.68,56.19 50.45,55.41 50.45,54.75 50.39,54.69 50.39,54.23 50.7,53.93 50.7,53.87
  IN4 w0.064: v11(50.03,51.92) 50.39,51.92 50.7,52.22 50.7,53.87
UART_BT_RXD_C: length 6.9
  TOP w0.114: R394.1 163.18,81.92 v9(162.71,81.92)
  IN3 w0.064: v1(160.26,78.12) 160.26,78.24 160.15,78.35 160.06,78.35 159.74,78.68 159.74,79.32 160.1,79.68 160.69,79.68 161.95,80.94 161.95,81.57 162.14,81.76 162.56,81.76 v9(162.71,81.92)
UART_BT_TXD: length 171.5
  IN2 w0.064: v4(163.95,81.41) 163.95,81.51 164.16,81.71 164.36,81.71 164.4,81.67 v5(164.4,81.41)
  IN3 w0.06: 50.64,54.59 50.64,55.86 49.78,56.72 49.78,57.49 49.43,57.85 49.43,58.47 v8(49.4,58.5)
  IN3 w0.064: v4(163.95,81.41) 163.8,81.56 163.57,81.56 163.34,81.33 163.34,79.25 161.21,77.12 161.21,76.61 158.8,74.2 152.71,74.2 147.02,68.52 133.33,68.52 132.28,67.46 129.07,67.46 127.87,66.27 127.87,58.13 126.01,56.26 124.03,56.26 122.5,54.73 122.5,48.29 113.99,39.78 107.21,39.78 105.71,38.28 105.71,37.51 102.7,34.49 81.61,34.49 81.35,34.24 71.81,34.24 66.87,39.17 48.91,39.17 45.85,42.23 45.85,48.39 49.55,52.1 49.82,52.1 50.14,52.41 50.14,52.78 50.01,52.91 50.01,53.34 50.64,53.98 50.64,54.59
UART_BT_TXD_C: length 6.9
  TOP w0.114: R393.1 163.28,81.69 163.06,81.69 162.71,81.33 v9(162.71,81.28)
  IN3 w0.064: v9(162.71,81.28) 162.71,81.41 162.53,81.59 162.21,81.59 162.12,81.5 162.12,80.86 160.77,79.5 160.17,79.5 159.92,79.25 159.92,78.75 160.14,78.53 160.22,78.53 160.26,78.57 v1(160.26,79.02)
UART_GPS_CTS: length 49.9
  IN2 w0.064: v4(28.04,26.24) 27.78,26.49 27.78,32.89 36.27,41.38 44.42,41.38 47.47,44.43 47.7,44.43 v4(47.9,44.22)
  IN3 w0.064: v4(28.04,26.24) 27.81,26 27.81,25.76 28.19,25.38 28.54,25.38 28.95,24.97 28.95,24.82 v1(29.11,24.66) ; v4(47.9,44.22) 47.7,44.43 47.45,44.43 47.29,44.58 47.29,47.17 48.77,48.65 48.77,48.74 v11(48.76,48.74)
  IN4 w0.06: v8(49.96,57.37) 49.88,57.29 49.88,57.01 49.76,56.89 49.76,56.65 49.96,56.45 49.96,56.09 50.62,55.42 50.62,54.31 50.9,54.03 50.9,53.67
  IN4 w0.064: v11(48.76,48.74) 49.04,49.02 49.38,49.02 50.36,50.01 50.36,51.18 50.9,51.71 50.9,53.67
UART_GPS_RTS: length 49.7
  IN2 w0.064: v4(27.4,26.24) 27.58,26.42 27.58,26.42 27.61,26.45 27.61,32.97 36.19,41.56 44.35,41.56 47.4,44.6 47.72,44.6 v4(47.9,44.78)
  IN3 w0.064: v4(27.4,26.24) 27.63,26 27.63,25.68 28.12,25.2 28.47,25.2 28.78,24.89 28.78,24.77 28.67,24.66 v1(28.22,24.66) ; v11(49.12,48.74) 47.47,47.09 47.47,44.65 47.52,44.6 47.72,44.6 v4(47.9,44.78)
  IN4 w0.06: v8(49.96,56.81) 49.96,56.62 50.08,56.5 50.08,56.14 50.74,55.47 50.74,54.36 51.05,54.05 51.05,53.54 51.08,53.51
  IN4 w0.064: 51.08,53.51 51.08,51.64 50.54,51.1 50.54,49.94 49.45,48.85 49.12,48.85 49.11,48.84 49.11,48.75 v11(49.12,48.74)
UART_GPS_RXD: length 53.4
  IN2 w0.064: v4(46.38,45.37) 46.12,45.11 45.62,45.11 42.57,42.06 35.89,42.06 26.74,32.92 26.74,22.76 27.02,22.48 27.23,22.48 v4(27.46,22.25)
  IN3 w0.06: 50.77,54.59 50.77,55.93 49.91,56.8 49.91,57.53 49.63,57.81 49.63,58.17 v8(49.68,58.22)
  IN3 w0.064: 50.77,54.59 50.77,53.8 50.21,53.24 50.21,52.99 50.34,52.86 50.34,50.06 49.58,49.3 48.46,49.3 46.81,47.65 46.81,45.29 46.68,45.16 46.58,45.16 v4(46.38,45.37) ; v4(27.46,22.25) 27.67,22.46 27.99,22.46 28.09,22.35 v1(28.09,22)
UART_GPS_TXD: length 52.5
  IN2 w0.064: v4(46.38,44.81) 46.25,44.93 45.69,44.93 42.64,41.89 35.96,41.89 26.92,32.84 26.92,22.84 27.1,22.66 27.23,22.66 v4(27.46,22.89)
  IN3 w0.06: v11(50.44,53.09) 50.52,53.01
  IN3 w0.064: v4(27.46,22.89) 27.72,22.63 27.96,22.63 28.09,22.76 v1(28.09,22.89) ; v4(46.38,44.81) 46.55,44.98 46.76,44.98 46.99,45.22 46.99,47.58 48.54,49.13 49.65,49.13 50.52,49.99 50.52,53.01
  IN4 w0.06: 49.98,54.59 50.31,54.92 50.31,55.35 49.47,56.19 49.47,56.53 49.63,56.69 49.63,56.85 49.48,57.01 49.48,57.17 49.68,57.37 v8(49.68,57.65)
  IN4 w0.064: 49.98,54.59 49.91,54.51 49.91,53.62 v11(50.44,53.09)
USB2_DEBUG_DN: length 1.8
  TOP w0.076: CN1.27 63.42,73.2 63.18,72.95 63.18,72.65 62.81,72.29 62.81,72.21 62.91,72.12 U4.4
USB2_DEBUG_DP: length 1.8
  TOP w0.076: CN1.26 63.02,72.72 62.36,72.05 U4.5
USB3_REXT0: length 6.9
  IN4 w0.06: 60.98,67.49 60.96,67.49 59.67,68.77 58.08,68.77 57.97,68.89 57.66,68.89 57.46,68.69 v8(57.32,68.69)
  IN4 w0.127: 60.98,67.49 62.23,67.49 62.63,67.08 62.63,66.83 62.97,66.49 v1(62.97,66.45)
USB3_REXT1: length 6.8
  IN4 w0.06: v8(57.04,68.97) 57.41,68.97 57.49,69.06 57.97,69.06 58.09,69.18 58.25,69.18 58.38,69.04 59.57,69.04 59.79,69.04 60.98,67.84
  IN4 w0.127: v1(62.94,67.34) 62.54,67.74 61.08,67.74 60.98,67.84
USB_3G_DN: length 137
  IN2 w0.07: v4(35.45,11.66) 35.58,11.66 35.84,11.4 35.84,11.26 35.79,11.2 35.22,11.2 34.23,12.19 30.66,12.19 27.5,15.34 27.5,20.32 29.33,22.14 29.33,25.14 35.15,30.96 38.07,30.96 41.27,34.16 41.27,34.67 43.84,37.24 55,37.24 55.4,36.84 71.86,36.84 74.22,39.2 74.22,43.21 76.7,45.69 76.7,46.01 76.99,46.3 76.99,50.95 77.54,51.5 77.54,54.99 77.12,55.4 76.55,55.4 76.28,55.68 76.28,60.17 77.28,61.17 77.28,71.56 78.53,72.8 78.53,73.01 v4(78.82,73.3)
  IN3 w0.07: v4(78.82,73.3) 78.76,73.3 78.56,73.5 78.56,73.86 78.36,74.07 78.36,74.5 77.75,75.1 70.28,75.1 69.78,74.6 69.78,72.31 68.96,71.49 60.94,71.49 59.74,70.28 58.62,70.28 58.49,70.42 58.49,70.66 58.57,70.75 58.66,70.75 v8(58.73,70.67) ; v1(35.46,10.82) 35.81,10.82 35.87,10.88 35.87,11.07 35.77,11.17 35.77,11.5 35.61,11.66 v4(35.45,11.66)
USB_3G_DP: length 137
  IN2 w0.07: v4(36.09,11.66) 36.01,11.58 36.01,11.19 35.86,11.03 35.14,11.03 34.16,12.02 30.59,12.02 27.33,15.27 27.33,20.39 29.16,22.22 29.16,25.21 35.08,31.14 38,31.14 41.1,34.24 41.1,34.74 43.77,37.41 55.07,37.41 55.47,37.01 71.79,37.01 74.05,39.27 74.05,43.28 76.53,45.76 76.53,46.08 76.82,46.37 76.82,51.03 77.37,51.57 77.37,54.92 77.05,55.23 76.48,55.23 76.1,55.6 76.1,60.24 77.11,61.24 77.11,71.63 78.36,72.87 78.36,73.12 v4(78.18,73.3)
  IN3 w0.07: v4(36.09,11.66) 35.94,11.51 35.94,11.24 36.04,11.14 36.04,10.9 36.12,10.82 v1(36.34,10.82) ; v8(58.45,70.95) 58.45,70.87 58.32,70.73 58.32,70.35 58.55,70.11 59.81,70.11 61.02,71.32 69.03,71.32 69.95,72.24 69.95,74.53 70.35,74.93 77.68,74.93 78.18,74.43 78.18,74 78.39,73.79 78.39,73.51 v4(78.18,73.3)
USB_DCIN_IDN: length 109.5
  TOP w0.114: PC27.1 100.22,76.32 R148.2 ; U12.C1 118.22,58.73 118.24,58.73 119.13,57.84 121.21,57.84 121.99,58.62 v5(121.99,58.78) ; R148.2 100.14,76.4 99.13,76.4 98.99,76.27 R149.2 ; R148.2 100.19,77.51 99.44,78.26 96.62,78.26 v5(96.16,77.8)
  IN2 w0.064: v5(96.16,77.8) 97.71,79.35 99.62,79.35 103.77,83.5 111.74,83.5 112.52,84.28 130.92,84.28 131.2,84.56 135.43,84.56 144.27,75.72 v4(144.27,72.75) 144.43,72.58 145.02,72.58 145.27,72.33 145.27,71.65 144.76,71.15 140.03,71.15 138.68,72.49 128.19,72.49 127.02,71.32 127.02,68.33 125.84,67.15 125.84,63.03 122.63,59.82 122.63,59.41 v5(121.99,58.78)
  IN3 w0.064: v4(144.27,72.75) 144.17,72.85 v1(144.17,73.23)
  BOTTOM w0.114: v1(144.17,73.23) 144.75,73.81 CN13.7
USB_DCIN_IDN_EC: length 32.8
  TOP w0.114: v5(115.36,60.96) 115.6,61.2 U12.H6
  IN2 w0.064: v5(115.36,60.96) 114.98,61.34 113.49,61.34 113.33,61.19 108.94,61.19 108.12,62 106.22,62 105.28,61.06 104.9,61.06 104.54,61.42 104.54,62.59 103.73,63.4 99.41,63.4 98.98,62.97 v4(97.91,62.97) ; v5(98.99,74.32) 98.98,74.32 98.07,73.41 98.07,71.93 v4(98.45,71.55)
  IN3 w0.064: v4(97.91,62.97) 97.96,63.02 97.96,68.33 98.45,68.81 v4(98.45,71.55)
USB_FS_DM_R: length 62.9
  IN2 w0.07: v9(142.11,72.62) 142.2,72.62 142.43,72.39 142.43,72.23 142.26,72.06 141.96,72.06 141.63,72.39 141.63,72.9 142.69,73.97 142.69,76.66 135.28,84.07 131.57,84.07 131.32,83.82 112.82,83.82 112.04,83.04 103.94,83.04 99.66,78.77 97.77,78.77 96.06,77.05 96.06,75.39 v5(95.96,75.29)
  BOTTOM w0.076: CN13.11 142.75,73.99 142.9,73.84 142.9,73.66 142.34,73.1 142.34,72.85 v9(142.11,72.62)
USB_FS_DP_R: length 62.9
  IN2 w0.07: v5(96.36,75.29) 96.23,75.42 96.23,76.98 97.84,78.6 99.74,78.6 104.01,82.87 112.11,82.87 112.89,83.64 131.39,83.64 131.64,83.9 135.21,83.9 142.52,76.59 142.52,74.04 141.46,72.97 141.46,72.32 141.89,71.89 142.33,71.89 142.6,72.16 142.6,72.42 v9(142.8,72.62)
  BOTTOM w0.076: CN13.10 143.25,74.05 143.05,73.85 143.05,73.6 142.49,73.04 142.49,72.92 v9(142.8,72.62)
USB_HSIC_RCOMP: length 1.5
  IN2 w0.114: v5(57.15,67.34) 56.92,67.34 56.59,67.67 56.59,67.72 v12(56.33,67.97)
  IN3 w0.127: v1(55.92,67.97) v12(56.33,67.97)
USB_P0_DN: length 6.7
  TOP w0.076: U4.2 62.91,70.22 62.67,69.98 62.06,69.98 61.74,70.3 61.74,70.55 61.43,70.87 60.41,70.87 59.84,71.44 59.84,71.86 59.74,71.96 v5(59.61,71.96)
  IN2 w0.07: v4(59.18,72.09) 59.48,72.09 v5(59.61,71.96)
  IN3 w0.07: v4(59.18,72.09) 59.41,72.09 59.49,72 59.49,71.83 59.18,71.52 v8(59.02,71.52)
USB_P0_DP: length 6.6
  TOP w0.076: U4.1 62.36,70.61 62.68,70.28 62.68,70.21 62.61,70.13 62.13,70.13 61.9,70.36 61.9,70.61 61.49,71.02 60.47,71.02 59.99,71.5 59.99,71.78 60.17,71.96 v5(60.47,71.96)
  IN2 w0.07: v5(60.47,71.96) 60.35,72.09 v4(60.04,72.09)
  IN3 w0.07: v8(59.38,71.24) 59.38,71.47 59.66,71.76 59.66,72.01 59.74,72.09 v4(60.04,72.09)
USB_P1_DN: length 39.1
  IN2 w0.07: v4(78.73,74.31) 78.88,74.31 79.04,74.47 79.04,74.76 79.23,74.95 79.78,74.95 80.87,73.86 91.61,73.86 92.2,74.45 93.15,74.45 v5(93.53,74.83)
  IN3 w0.07: v4(78.73,74.31) 78.9,74.31 79.05,74.46 79.05,74.68 78.16,75.57 67.3,75.57 65.14,73.41 63.2,73.41 61.73,71.94 60.73,71.94 59.59,70.8 59.27,70.8 59.12,70.95 v8(59.02,70.95)
USB_P1_DP: length 39.1
  IN2 w0.07: v4(79.37,74.31) 79.21,74.47 79.21,74.69 79.3,74.78 79.71,74.78 80.8,73.69 91.69,73.69 92.27,74.28 93.19,74.28 v5(93.53,73.94)
  IN3 w0.07: v8(58.73,71.24) 58.81,71.24 58.86,71.19 59.13,71.19 59.35,70.97 59.52,70.97 60.66,72.11 61.65,72.11 63.13,73.58 65.07,73.58 67.23,75.74 78.23,75.74 79.22,74.75 79.22,74.46 v4(79.37,74.31)
USB_RCOMP: length 1.3
  IN2 w0.064: v12(58.05,70.15) 57.66,70.15 v5(57.64,70.13)
  IN3 w0.064: v12(58.05,70.15) 58,70.15 57.96,70.1 v8(57.6,70.1)
  BOTTOM w0.114: U29.J7 v8(57.6,70.1)
USIM_DETECT: length 202.1
  TOP w0.114: R178.1 T9.2 117.51,69.78 J1.1
  IN2 w0.064: v4(50.54,80.9) 50.62,80.98 56.8,80.98 58.39,79.39 63,79.39 63.47,78.92 63.47,77.75 v4(63.57,77.65) 65.07,79.15 69.04,79.15 69.55,78.64 69.55,78.27 70.53,77.29 80.14,77.29 80.85,78 82.84,78 83.5,77.34 84.76,77.34 86.15,75.95 86.43,75.95 86.64,76.15 86.64,77.6 87.78,78.74 91.46,78.74 95.7,74.5 97.66,74.5 98.37,75.21 101.77,75.21 103.78,77.22 105.71,77.22 108.1,74.83 108.82,74.83 110.11,73.54 110.11,72.04 112.02,70.13 117.14,70.13 v5(117.62,69.65)
  IN3 w0.064: v4(50.54,80.9) 49.38,82.06 24.91,82.06 23.67,80.82 23.67,50.42 20.95,47.7 20.95,42.44 22.88,40.51 22.88,34.43 21.14,32.69 21.14,31.1 17.93,27.89 17.93,15.36 18.56,14.73 18.56,11.43 17.12,9.98 17.12,9.78 19.05,7.85 20.95,7.85 21.31,7.49 v1(21.31,5.72) ; v4(63.57,77.65) 63.01,77.09 63.01,76.59 62.17,75.74 59,75.74 58.8,75.94 58.8,76.35 58.6,76.55 58.33,76.55 57.96,76.18 v1(57.96,76.13)
USIM_DETECT_R: length 6.2
  IN4 w0.06: v8(55.62,70.95) 55.71,70.95 55.95,71.2 55.95,71.97 57.71,73.72 57.71,74.63 v1(57.17,75.16)
  BOTTOM w0.114: R308.2 R402.1
V_GPS_1V8: length 7.2
  IN3 w0.254: v1(29.79,20.52) 30.43,20.52 32.28,22.38 32.28,23.52 v1(33.55,24.79)
  BOTTOM w0.254: U22.A4 30.3,21.04 v1(29.79,20.52)
V_GPS_3V3: length 11.4
  TOP w0.508: v9(33.14,22.96) 31.21,22.96 30.02,21.77 30.02,16.87 v9(29.97,16.82)
  BOTTOM w0.254: 33.93,22.19 33.89,22.19 33.14,21.44 U22.E3
  BOTTOM w0.508: v9(29.97,16.82) 29.97,16.71 29.87,16.61 C192.1
V_LNA_1V8_GPS: length 23.4
  IN2 w0.254: v4(31.65,23.62) 31.65,21.24 30.35,19.94 30.35,17.17 32.1,15.42 35.99,15.42 v4(36.09,15.52)
  IN3 w0.254: v1(31.9,24.03) 31.65,23.78 v4(31.65,23.62) ; v4(36.09,15.52) 36.38,15.23 v1(36.73,15.23)
  IN4 w0.254: v1(35.24,24.92) 34.86,25.3 34.26,25.3 33.93,24.97 33.93,24.54 33.51,24.12 31.99,24.12 v1(31.9,24.03) 31.65,23.78 v4(31.65,23.62) 32.2,23.06 32.2,21.67 31.97,21.44 v1(31.79,21.44)
  BOTTOM w0.254: Y2.4 34.99,24.27 35.24,24.52 v1(35.24,24.92)
V_LNA_1V8_GPS_L: length 3.5
  IN3 w0.254: v1(38.5,16.07) 38.5,16.08 v1(38.5,17.76)
  BOTTOM w0.254: v1(38.5,16.07) C223.1 L8.1
VD_VBUS_CON: length 6
  TOP w0.381: v14(101.75,59.41) 101.61,59.27 100.67,59.27 99.97,59.97 97.76,59.97 97.3,60.43 PR145.2 PR146.2
  vias: v14(101.75,58.65) v14(101.75,57.89) v14(102.46,59.41) v14(102.46,58.65) v14(102.46,57.91) v14(103.2,59.41) v14(103.2,58.68) v14(132.13,83.26) v14(132.15,82.42) v14(132.89,83.26) v14(132.91,82.4) v14(142.54,80.14) v14(142.54,79.35) v14(143.15,81.48) v14(143.15,80.49) v14(143.15,79.73) v14(143.18,79.02) v14(143.86,81.51) v14(144.57,81.51) v14(145.28,81.51)
VOLUME_DOWN: length 166.6
  TOP w0.114: PR150.2 90.32,65.3 90.7,65.69 90.7,66.37 90.98,66.65 90.98,72.89 92,73.91 92,75.26 v5(91.94,75.31) ; v5(50.59,79.86) 49.48,80.98 44.76,80.98 R25.2
  IN2 w0.064: v5(50.59,79.86) 50.62,79.86 50.92,79.55 51.36,79.55 52.23,80.43 56.58,80.43 58.16,78.84 62.61,78.84 62.9,78.55 62.9,77.24 63.54,76.6 65.02,76.6 65.55,77.13 68.15,77.13 68.29,77 69.79,77 70.23,76.56 79.3,76.56 81.23,74.63 87.75,74.63 88.61,75.48 91.77,75.48 v5(91.94,75.31) 92.12,75.48 93.72,75.48 98.45,70.76 98.45,68.51 99.83,67.12 105.33,67.12 106.15,66.29 109.13,66.29 109.35,66.51 110.45,66.51 v4(110.69,66.75)
  IN3 w0.064: v4(110.69,66.75) 110.26,66.33 110.26,61.26 106.83,57.82 106.83,53.52 103.65,50.34 102.52,50.34 98.94,46.76 91.75,46.76 91.23,46.24 89.16,46.24 v1(89.05,46.13) 88.1,47.08 87.14,47.08 86.11,46.05 85.01,46.05 83.86,47.19 74.16,47.19 71.75,49.6 69.69,49.6 69.37,49.92 67.95,49.92 67.74,50.12 66.9,50.12 64.18,52.84 64.18,53.21 63,54.38 62.05,54.38 61.76,54.67 58.53,54.67 58.06,55.14 v11(57.68,55.14)
  IN4 w0.06: v11(57.68,55.14) 57.68,55.3 57.16,55.82 57.16,56.87 57.24,56.96 57.24,57.29 v8(57.32,57.37)
  BOTTOM w0.114: R333.1 89.16,42.23 88.67,42.72 88.67,45.75 v1(89.05,46.13)
VOLUME_UP: length 191.9
  TOP w0.114: v9(20.01,83.4) 20.43,82.99 20.43,81.4 20.85,80.98 39.65,80.98 40.28,81.61 43.71,81.61 43.86,81.46 43.86,81.05 44.17,80.75 49.22,80.75 v5(50.11,79.86) ; PR149.2 89.72,72.61 90.78,73.66 91.46,73.66 91.79,73.99 91.79,75.03 v5(91.59,75.24)
  IN2 w0.064: v4(111.32,66.78) 110.91,66.36 109.41,66.36 109.18,66.13 106.1,66.13 105.26,66.97 99.77,66.97 98.22,68.52 98.22,70.77 93.76,75.23 92.92,75.23 92.75,75.06 91.77,75.06 v5(91.59,75.24) 91.58,75.23 88.57,75.23 87.82,74.47 81.15,74.47 79.22,76.4 70.16,76.4 69.73,76.84 68.21,76.84 68.08,76.98 65.61,76.98 65.08,76.45 63.48,76.45 62.75,77.18 62.75,78.46 62.52,78.69 58.1,78.69 56.51,80.28 52.33,80.28 51.41,79.35 50.77,79.35 50.49,79.63 50.34,79.63 v5(50.11,79.86)
  IN3 w0.06: v11(57.93,54.89) 58.32,54.5 60.1,54.5 60.22,54.38 60.86,54.38
  IN3 w0.064: 60.86,54.38 61.83,54.38 61.99,54.23 62.94,54.23 64.02,53.15 64.02,52.78 66.83,49.97 67.68,49.97 67.88,49.77 69.31,49.77 69.63,49.45 71.68,49.45 74.12,47.01 83.82,47.01 84.94,45.89 86.17,45.89 87.21,46.93 88.03,46.93 88.54,46.42 v1(88.54,46.13) 88.8,45.87 89.22,45.87 89.43,46.08 91.29,46.08 91.82,46.61 99.03,46.61 102.54,50.12 103.64,50.12 106.98,53.46 106.98,57.76 110.42,61.19 110.42,65.87 v4(111.32,66.78)
  IN4 w0.06: v11(57.93,54.89) 57.93,55.3 57.28,55.96 57.28,56.69 v8(57.36,56.77)
  BOTTOM w0.114: v1(88.54,46.13) 88.41,46 88.41,42.36 R332.1 ; v9(20.01,83.4) R226.2
VREF25: length 6.9
  IN2 w0.254: v12(86.66,66.32) 86.66,66.68 86.64,66.7 v5(86.64,66.75)
  IN2 w0.381: v5(85.11,66.09) 84.99,66.22 v12(84.99,66.52)
  IN3 w0.254: v12(84.99,66.52) 84.88,66.42 v8(84.88,65.15) ; v8(83.68,65.15) 83.38,65.44 83.38,66.3 v12(82.95,66.73) ; v12(86.66,66.32) v11(86.66,65.91)
  GND3 w0.254: v8(84.88,61.55) v12(85.27,61.55) ; v8(82.48,63.55) 82.48,63.67 82.32,63.83 v12(81.66,63.83)
  IN4 w0.254: v8(86.48,65.15) 86.48,65.73 v11(86.66,65.91)
  vias: v2(85.26,62.52) v3(81.66,64.34) v3(85.26,62.52) v5(81.66,64.34) v5(85.26,62.52)
VS_BAT_FG: length 17.3
  TOP w0.127: v5(118.89,45.76) 118.89,45.26 TP20.1 118.92,44.53 118.65,44.53 PC33.2
  IN2 w0.064: v4(110.87,53.09) 111.02,53.24 113.41,53.24 113.87,52.78 113.87,50.7 117.93,46.64 118.94,46.64 119.17,46.41 119.17,46.04 v5(118.89,45.76)
  IN3 w0.064: v4(110.87,53.09) 110.77,52.99 v1(110.39,52.99)
  BOTTOM w0.114: v1(110.39,52.99) 109.75,53.63 SS3.1
VS_BAT_R: length 41.2
  IN1 w0.127: v5(108.12,63.17) 108.12,62.08 108.86,61.34 108.86,60.78 110.22,59.42 110.22,58.41 110.44,58.19 110.44,56.97 109.8,56.34 109.8,53.85 v5(109.95,53.7)
  IN2 w0.127: v12(84.76,64.33) 84.91,64.48 84.91,65.18 85.65,65.91 87.04,65.91 87.35,66.22 87.35,66.83 88.19,67.67 88.67,67.67 88.91,67.43 89.47,67.43 89.68,67.64 92.48,67.64 96.39,63.73 107.57,63.73 v5(108.12,63.17) ; v5(109.95,53.7) 109.95,53.42 v4(110.89,52.48)
  IN3 w0.127: v12(84.76,64.33) 84.76,64.07 v8(84.88,63.95) ; v1(110.11,52.73) 110.23,52.6 110.77,52.6 v4(110.89,52.48)
  vias: v1(109.32,52.38) v1(109.29,52) v1(109.29,51.67) v1(109.29,51.33) v1(109.29,50.95) v1(109.7,52.38) v1(109.7,52) v1(109.7,51.67) v1(109.7,51.33) v1(109.7,50.95) v1(110.03,52.38) v1(110.03,52) v1(110.03,51.67) v1(110.03,51.33) v1(110.03,50.95) v1(110.36,52.38) v1(110.36,52) v1(110.36,51.67) v1(110.36,51.33) v1(110.36,50.95) v1(113.36,52.3) v1(113.38,51.92) v1(113.38,51.54) v1(113.38,51.13) v1(113.36,50.73) v1(113.71,52.3) v1(113.76,51.94) v1(113.79,51.46) v1(114.09,52.3) v1(114.09,51.94) v1(114.14,51.49) v1(114.45,52.3) v1(114.45,51.94) v1(114.53,51.49) v1(114.8,52.3) v1(114.8,51.92) v1(114.86,51.49) v1(115.13,52.3) v1(115.13,51.92) v1(115.19,51.49)
W_DISABLE_R#: length 6.5
  BOTTOM w0.114: R280.1 34.57,9.17 33.8,8.41 33.8,7.52 34.31,7.01 35.71,7.01 36.3,6.42 CN7.6
WF_IRQ_R: length 13.4
  IN3 w0.064: v1(148.99,80.27) 148.74,80.52 148.74,81.28 149.22,81.76 159.05,81.76 159.41,81.41 159.41,81.13 159.72,80.82 v1(160.26,80.82)
WIFI_EN: length 54.2
  TOP w0.114: v5(140.2,72.06) 142.56,69.71 PR38.1 143.41,69.71 143.44,69.75 PQ3.2 ; U12.A5 116.1,56.97 117.04,56.03 117.04,54.61 117.31,54.33 v5(118.34,54.33)
  IN2 w0.064: v5(140.2,72.06) 139.62,72.65 128.09,72.65 126.82,71.38 126.82,68.4 125.69,67.27 125.69,63.26 122.27,59.84 122.27,59.59 121.67,58.99 121.67,58.1 121.97,57.8 121.97,55.55 122.27,55.25 122.27,51.26 121.36,50.34 119.78,50.34 118.82,51.31 118.82,52.6 118.34,53.09 v5(118.34,54.33)
WIFI_PALDO_EN: length 19.9
  TOP w0.305: R190.1 R191.2 152.62,82.06 U14.C2
  TOP w0.508: R190.1 153.88,79.86 v9(152.42,79.86) ; v9(158.01,74.93) 158.01,74.55 157.19,73.73 U13.3
  IN2 w0.508: v9(152.42,79.86) 152.42,79.12 151.41,78.11 151.41,76.46 152.3,75.57 155.6,75.57 156.23,74.93 v9(158.01,74.93)
  BOTTOM w0.254: v9(158.01,74.93) 157.96,74.98 157.25,74.98 156.78,74.52 U36.K4
WL_DEV_EN: length 124.7
  IN2 w0.064: v4(81.38,75.64) 81.51,75.52 84.71,75.52 85.11,75.11 86.64,75.11 87.32,75.79 94.07,75.79 95.61,74.25 97.76,74.25 98.47,74.96 101.89,74.96 103.85,76.92 105.45,76.92 v4(105.86,76.51)
  IN3 w0.064: v1(147.98,81.15) 147.22,80.39 147.22,79.85 138.99,71.62 131.66,71.62 130.63,70.59 127.78,70.59 124.77,67.58 124.77,66.49 121.55,63.27 118.01,63.27 117.05,64.23 117.05,69.31 114.96,71.4 111.15,71.4 110.28,70.54 109.83,70.54 109.65,70.72 109.65,71.7 110.2,72.25 110.2,73.92 109.74,74.38 107.15,74.38 105.86,75.67 v4(105.86,76.51) ; v4(81.38,75.64) 81.18,75.85 79.98,75.85 79.27,76.56 77.4,76.56 76.66,77.29 66.31,77.29 64.84,78.77 57.54,78.77 56.85,78.07 55.43,78.07 55.1,77.75 v11(54.89,77.75)
  IN4 w0.06: v8(53.07,71.88) 53.25,71.88 53.79,72.42 53.79,74.57 54.4,75.19
  IN4 w0.064: 54.54,75.25 54.46,75.25 54.4,75.19
  IN4 w0.127: v11(54.89,77.75) 54.89,77.71 54.76,77.58 54.76,75.46 54.54,75.25
WL_HOST_WAKE: length 145.9
  IN2 w0.064: v4(81.38,76.2) 81.84,76.2 82.14,75.9 85.34,75.9 85.87,75.36 86.68,75.36 87.65,76.34 87.69,76.34 88.13,76.79 v4(88.13,78.28)
  IN3 w0.06: v8(53.64,69.54) 53.64,69.87 53.53,69.98 53.53,71.78
  IN3 w0.064: v1(158.46,78.12) 158.46,79.8 159.2,80.54 159.2,81.39 158.97,81.61 155.96,81.61 155,80.65 153.44,80.65 152.9,81.18 150.29,81.18 149.12,80.01 147.6,80.01 139.05,71.46 131.72,71.46 130.69,70.44 127.85,70.44 124.93,67.52 124.93,66.42 121.62,63.11 117.95,63.11 116.9,64.16 116.9,69.21 114.86,71.25 111.21,71.25 110.35,70.38 109.75,70.38 109.5,70.64 109.5,71.77 110.05,72.32 110.05,73.86 109.68,74.23 106.82,74.23 102.72,78.33 96.52,78.33 95.23,77.04 88.72,77.04 88.13,77.62 v4(88.13,78.28) 88.11,78.28 87.75,77.93 v1(87.53,77.93) ; 53.53,71.78 53.53,72.14 53.61,72.21 53.61,76.56 54.1,77.05 54.1,77.36 54.25,77.51 54.25,78.03 54.84,78.61 56.61,78.61 57.3,79.3 65.06,79.3 65.94,78.42 76.28,78.42 77.62,77.09 79.51,77.09 80.02,76.58 81,76.58 v4(81.38,76.2)
  BOTTOM w0.114: R330.1 87.51,77.92 v1(87.53,77.93)
WLBT_1V8: length 16.7
  TOP w0.508: R390.1 160.76,82.24 v9(160.73,82.27) 160.76,82.31 R187.2
  IN2 w0.508: v9(160.73,82.27) 157.83,82.27 v9(153.31,77.75)
  BOTTOM w0.381: U36.H1 153.96,76.52 153.48,77 153.48,77.58 v9(153.31,77.75) 152.6,78.46 150.09,78.46 149.69,78.07 C372.2
WLBT_3V3: length 18.3
  TOP w0.254: R191.1 C361.2 C362.1 154.96,82.81 155.34,82.42 v9(155.34,82.17)
  IN1 w0.508: 151.28,71.88 151.28,73.61 151.84,74.17 155.5,74.17 155.95,74.63 155.95,75.72 155.34,76.33 v9(155.34,82.17)
  BOTTOM w0.254: U36.A2 154.9,82.62 v9(155.34,82.17)
  vias: v2(151.33,72.04) v2(151.3,71.65)
WP#_FLASH: length 2.8
  TOP w0.114: R83.1 62.44,42.36 63.1,43.02 v9(63.1,43.07)
  BOTTOM w0.114: v9(63.1,43.07) 62.51,43.66 U30.3
WWAN_OFF#: length 206.7
  IN2 w0.064: 50.82,82.04 50.34,82.53 23.62,82.53 21.87,80.77 11.76,80.77 9.72,78.74 9.72,67.29 8.71,66.27 8.71,61.98 9.04,61.65 12.54,61.65 12.67,61.52 12.67,44.76 13.13,44.3 14.4,44.3 15.16,43.54 18.77,43.54 24.51,37.8 24.51,31.8 25.12,31.19 25.12,11.94 29.08,7.98 33.3,7.98 v4(34.29,8.97) ; 50.82,82.04 v4(50.82,82.02) ; 50.82,82.04 50.82,82.09 51.13,82.4 53.34,82.4 53.55,82.61 56.1,82.61 58.69,80.01 66.28,80.01 66.51,79.78 68.09,79.78 v4(68.91,80.6) ; v12(79.07,68.86) 78.64,68.86 77.95,68.18 77.95,65.14 v5(77.61,64.8)
  IN3 w0.064: v4(68.91,80.6) 69.03,80.47 80.84,80.47 81.94,79.38 84.07,79.38 84.96,78.49 84.96,78.23 84.81,78.08 84.81,77.75 84.96,77.6 84.96,77.34 84.73,77.12 84.73,76.84 84.88,76.69 84.88,76.41 84.18,75.71 84.18,71.66 81.98,69.47 79.63,69.47 79.07,68.91 v12(79.07,68.86) ; v4(50.82,82.02) 50.9,81.94 50.9,80.69 50.64,80.43 50.64,78.94 v11(50.62,78.92) ; v4(34.29,8.97) 34.29,9.3 34.46,9.48 34.46,10.72 v1(34.57,10.82)
  IN4 w0.06: v8(55.34,71.88) 55.66,72.2 55.66,73.6 55.57,73.69 55.57,74.96 v1(55.44,75.08)
  IN4 w0.127: v11(50.62,78.92) 50.62,78.74 50.77,78.59 56.08,78.59 56.28,78.39 56.28,75.92 v1(55.44,75.08)
WWAN_WAKE#: length 152.7
  IN2 w0.064: v4(51.38,81.99) 51.05,81.66 48.41,81.66 47.7,82.37 23.86,82.37 22.03,80.54 11.82,80.54 9.93,78.65 9.93,67.21 8.89,66.17 8.89,62.08 9.14,61.83 12.58,61.83 12.82,61.58 12.82,44.91 13.23,44.5 14.45,44.5 15.21,43.74 18.82,43.74 24.69,37.87 24.69,31.9 25.4,31.19 25.4,12.06 29.2,8.26 32.13,8.26 32.66,8.79 v4(32.66,9.02)
  IN3 w0.064: v4(51.38,81.99) 51.08,81.69 51.08,80.64 50.79,80.36 50.79,79.13 v11(51,78.92) ; v1(32.79,10.82) 32.66,10.69 v4(32.66,9.02)
  IN4 w0.06: v8(55.34,69.54) 55.34,69.82 55.54,70.02 55.54,70.75 55.39,70.9 55.39,71.01 55.54,71.15 55.54,71.32 55.41,71.45 55.41,71.6 55.55,71.73 55.55,71.9 56.69,73.04 56.69,74.6 56.26,75.03 v1(56.26,75.19)
  IN4 w0.127: v1(56.26,75.19) 56.69,75.62 56.69,78.56 56.41,78.84 51.08,78.84 v11(51,78.92)
XDP_BPM0: length 4
  TOP w0.114: R45.1 53.87,76.96 54.35,76.48 54.89,76.48 55.39,75.97 56.46,75.97 56.62,75.81 CN1.51
XDP_BPM1: length 3.5
  TOP w0.114: CN1.50 57.02,75.74 56.59,76.18 55.57,76.18 54.63,77.12 R48.1
XDP_BPM2: length 3.2
  TOP w0.114: CN1.49 57.42,75.72 56.77,76.38 55.88,76.38 55.39,76.86 R52.1
XDP_BPM3: length 2.9
  TOP w0.114: CN1.48 57.82,75.83 57.68,75.97 57.46,75.97 56.85,76.58 56.4,76.58 56.16,76.82 R54.1
XDP_CORE_PWROK: length 4.6
  TOP w0.114: R89.1 66.07,76.76 64.97,76.76 64.74,76.53 63.73,76.53 63.02,75.83 CN1.35
XDP_H_PRDY#: length 6.4
  IN2 w0.064: v12(57.5,75.46) 57.47,75.5 v5(55.42,75.5)
  IN3 w0.064: v8(56.47,71.88) 56.46,71.89 56.46,72.4 57.88,73.83 57.88,74.09 57.83,74.14 57.83,75.13 v12(57.5,75.46)
XDP_H_PREQ#: length 16.9
  IN2 w0.064: v12(58.47,75.72) 58.32,75.87 55.42,75.87 55.05,75.5 v5(55.02,75.5)
  IN3 w0.06: 57.1,71.78 57.1,71.4 56.92,71.22 56.69,71.22 56.54,71.07 56.54,70.74 v8(56.47,70.67)
  IN3 w0.064: v1(62.46,75.49) 62.45,75.5 58.69,75.5 v12(58.47,75.72) 58.14,75.39 58.14,74.27 58.19,74.22 58.19,73.7 57.1,72.61 57.1,71.78
  BOTTOM w0.114: R328.1 65.08,75.01 62.61,75.01 62.46,75.16 v1(62.46,75.49)
