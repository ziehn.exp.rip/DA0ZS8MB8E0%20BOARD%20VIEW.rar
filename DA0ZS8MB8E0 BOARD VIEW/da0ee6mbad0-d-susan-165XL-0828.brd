# Allegro board da0ee6mbad0-d-susan-165XL-0828.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
M_0_DQ59: length 22.5
  IN3 w0.06: v8(32.51,70.81) 32.39,70.81 32.19,71.01 31.48,71.01 30.59,70.12 30.59,69.01 ; 42.85,65.13 42.92,65.13 43.25,64.79 46.44,64.79 46.56,64.91 46.56,65.02 46.47,65.11 46.37,65.11 46.28,65.03 v8(46.28,65.01)
  IN3 w0.064: 42.85,65.13 33.17,65.13 30.59,67.71 30.59,69.01
M_0_DQ60: length 21.7
  IN3 w0.06: v8(46,65.86) 44.17,65.86 44.07,65.97 43.76,65.97 42.87,66.85 42.85,66.85 ; 32.86,69.01 32.86,69.02 32.8,69.09 32.72,69.09 32.66,69.15 32.66,69.24 32.72,69.31 32.83,69.31 33.3,69.78 33.61,69.78 33.65,69.83 33.65,70.16 33.58,70.23 33.47,70.23 33.4,70.16 33.4,70.08 33.32,70 32.97,70 32.9,69.93 32.9,69.78 32.75,69.64 v8(32.75,69.56)
  IN3 w0.064: 32.86,69.01 32.86,68.91 32.79,68.84 32.79,68.74 33.38,68.16 33.92,68.16 34,68.07 34.07,68.07 34.25,68.25 34.34,68.25 34.4,68.18 34.4,68.09 34.24,67.93 34.24,67.83 34.3,67.77 34.4,67.77 34.56,67.93 34.65,67.93 34.72,67.87 34.72,67.78 34.55,67.61 34.55,67.52 34.62,67.45 34.71,67.45 34.88,67.62 34.97,67.62 35.03,67.56 35.03,67.46 34.94,67.37 34.94,67.28 35.01,67.21 35.1,67.21 35.19,67.31 35.28,67.31 35.35,67.24 35.35,67.15 35.25,67.06 35.25,66.96 35.33,66.88 35.43,66.88 35.53,66.98 35.61,66.98 35.71,66.89 35.71,66.8 35.77,66.74 36.03,66.74 36.14,66.85 36.28,66.85 36.39,66.74 36.53,66.74 36.64,66.85 36.79,66.85 36.9,66.74 37.04,66.74 37.15,66.85 37.3,66.85 37.41,66.74 37.55,66.74 37.66,66.85 37.8,66.85 37.91,66.74 38.06,66.74 38.17,66.85 38.31,66.85 38.42,66.74 38.57,66.74 38.68,66.85 38.82,66.85 38.93,66.74 39.07,66.74 39.18,66.85 39.33,66.85 39.44,66.74 39.58,66.74 39.69,66.85 39.84,66.85 39.95,66.74 40.09,66.74 40.2,66.85 40.34,66.85 40.45,66.74 40.6,66.74 40.71,66.85 40.85,66.85 40.96,66.74 41.11,66.74 41.22,66.85 41.36,66.85 41.47,66.74 41.61,66.74 41.72,66.85 41.87,66.85 41.98,66.74 42.12,66.74 42.23,66.85 42.38,66.85 42.49,66.74 42.61,66.74 42.72,66.85 42.85,66.85
  BOTTOM w0.114: U23.F16 32.51,69.8 v8(32.75,69.56)
M_0_DQ61: length 22
  IN3 w0.06: 42.85,64.92 42.9,64.92 43.15,64.67 46.51,64.67 v8(46.85,65.01) ; v8(31.51,71.31) 30.4,70.2 30.4,69.01
  IN3 w0.064: 30.4,69.01 30.4,67.63 33.11,64.92 42.85,64.92
M_0_DQ62: length 21.9
  IN3 w0.06: v8(46.85,65.58) 46.83,65.56 46.83,65.28 46.91,65.2 47.01,65.2 47.09,65.28 47.09,65.36 47.16,65.43 47.27,65.43 47.34,65.36 47.34,65.27 47.41,65.2 47.5,65.2 47.57,65.27 47.57,65.64 47.49,65.71 47.01,65.71 46.93,65.8 46.72,65.8 46.61,65.69 46.46,65.69 46.35,65.8 46.22,65.8 46.08,65.66 45.92,65.66 45.86,65.66 45.79,65.73 43.99,65.73 43.91,65.81 43.74,65.81 43,66.55 42.85,66.55 ; 32.49,69.01 32.44,69.06 32.27,69.06 32.2,69.13 32.2,69.23 32.27,69.29 32.47,69.29 32.55,69.37 32.55,69.64 32.68,69.77 32.68,69.86 32.61,69.92 32.52,69.92 32.24,69.64 v8(32.24,69.56)
  IN3 w0.064: 42.85,66.55 35.25,66.55 35.17,66.63 35.17,66.78 34.84,67.11 34.54,67.11 34.43,67.22 34.43,67.37 33.84,67.97 33.57,67.97 33.37,67.77 33.24,67.77 33.07,67.94 33.07,68.19 32.69,68.58 32.33,68.58 32.26,68.64 32.26,68.74 32.33,68.81 32.43,68.81 32.5,68.87 32.5,69 32.49,69.01
  BOTTOM w0.114: v8(32.24,69.56) 32.01,69.79 U23.E16
M_0_DQ63: length 21.6
  IN3 w0.06: 42.85,67.26 42.87,67.26 43.86,66.27 44.21,66.27 44.38,66.1 45.78,66.1 45.86,66.18 46.04,66.18 46.13,66.28 46.24,66.28 46.28,66.24 v8(46.28,66.14) ; v8(32.01,71.31) 32.01,71.43 32.08,71.5 32.31,71.5 32.38,71.58 32.38,71.76 32.43,71.81 32.56,71.81 32.62,71.74 32.62,71.49 32.69,71.43 32.78,71.43 32.84,71.49 32.84,71.73 32.92,71.81 33.02,71.81 33.09,71.74 33.09,71.54 33.15,71.48 33.24,71.48 33.3,71.54 33.3,71.74 33.37,71.81 33.46,71.81 33.52,71.74 33.52,71.27 33.6,71.2 33.83,71.2 33.91,71.12 33.91,69.62 33.98,69.55 33.98,69.47 33.88,69.37 33.78,69.37 33.66,69.48 33.36,69.48 33.25,69.37 33.25,69.01
  IN3 w0.064: 42.85,67.26 35.87,67.26 34.32,68.81 34.08,68.81 33.81,68.54 33.53,68.54 33.25,68.83 33.25,69.01
M_0_DQSN0: length 22.4
  IN3 w0.06: v8(36.01,74.31) 36.04,74.27 36.27,74.27 36.44,74.44 36.76,74.44 36.9,74.58 36.9,75 36.77,75.13 36.77,76.25 36.97,76.46 37.08,76.46 37.27,76.65 38.25,76.65 38.27,76.63 38.27,76.63 ; 47.93,71.78 47.93,71.77 47.94,71.75 47.94,70.19 48.06,70.08 48.06,69.61 v8(47.98,69.54)
  IN3 w0.083: 38.27,76.63 38.42,76.63 38.59,76.79 38.59,77.13 38.48,77.24 38.48,77.5 38.57,77.59 41.18,77.59 41.27,77.5 41.27,77.23 41.44,77.06 41.76,77.06 41.93,77.23 41.93,77.5 42,77.57 42.19,77.57 42.26,77.5 42.26,77.23 42.43,77.06 42.75,77.06 42.92,77.23 42.92,77.52 43,77.6 43.2,77.6 43.27,77.52 43.27,76.8 43.44,76.63 44.18,76.63 47.93,72.88 47.93,71.78
M_0_DQSN1: length 20.9
  IN4 w0.06: v8(47.7,71.52) 47.8,71.62 47.8,72.33 47.96,72.49 47.96,73.29 47.84,73.41 47.84,74.09 47.82,74.11 47.82,74.12 ; 38.2,75.8 38.19,75.8 38.17,75.81 37.47,75.81 v8(37.25,76.04)
  IN4 w0.076: 47.82,74.12 47.82,74.91 44.96,77.78 44.41,77.78 44.12,78.07 44.12,78.62 44.04,78.7 43.86,78.7 43.79,78.62 43.79,78.2 43.62,78.03 43.32,78.03 43.15,78.2 43.15,78.61 43.08,78.69 42.9,78.69 42.82,78.61 42.82,78.2 42.66,78.03 42.35,78.03 42.19,78.2 42.19,78.6 42.1,78.69 41.91,78.69 41.63,78.41 39.01,78.41 38.55,77.95 38.55,76 38.35,75.8 38.2,75.8
  BOTTOM w0.102: U23.R4 v8(37.25,76.04)
M_0_DQSN2: length 16.4
  IN4 w0.06: 38.2,71.52 37.3,71.52 v8(37.01,71.81) ; v8(46,71.52) 45.94,71.58 45.94,72.21 44.99,73.16 44.99,73.7 44.86,73.83 44.84,73.83 44.83,73.84
  IN4 w0.076: 38.2,71.52 38.34,71.52 38.63,71.81 38.63,72.05 39.34,72.76 39.34,73.37 40.27,74.3 40.61,74.3 40.79,74.47 40.79,74.83 40.87,74.91 41.04,74.91 41.12,74.83 41.12,74.46 41.28,74.3 41.59,74.3 41.75,74.46 41.75,74.86 41.83,74.93 42.01,74.93 42.08,74.86 42.08,74.46 42.25,74.3 42.55,74.3 42.72,74.46 42.72,75.01 42.8,75.08 42.97,75.08 43.05,75.01 43.05,74.46 43.22,74.3 43.52,74.3 43.68,74.46 43.68,74.65 43.76,74.73 43.94,74.73 44.01,74.65 44.01,74.44 44.15,74.3 44.37,74.3 44.83,73.84
M_0_DQSN3: length 14.4
  IN3 w0.06: v8(46,70.39) 46,70.48 45.87,70.61 45.87,70.99 45.25,71.62 45.22,71.62 45.21,71.62 ; 38.27,72.15 38.27,72.15 38.25,72.17 37.64,72.17 37.11,72.7 37.05,72.7 36.9,72.85 36.9,73.19 36.85,73.24 36.77,73.24 36.55,73.46 36.55,73.53 36.5,73.59 36.29,73.59 v8(36.26,73.55)
  IN3 w0.083: 45.21,71.62 43.76,73.07 40.1,73.07 40.06,73.03 40.06,72.53 39.89,72.36 39.55,72.36 39.38,72.53 39.38,72.71 39.31,72.79 39.12,72.79 39.04,72.71 39.04,71.95 38.87,71.78 38.54,71.78 38.37,71.95 38.37,72.1 38.31,72.15 38.27,72.15
  BOTTOM w0.102: v8(36.26,73.55) 36.26,73.47 36.09,73.31 U23.N9
M_0_DQSN4: length 16.2
  IN3 w0.06: 35.66,69.01 35.65,69.02 35.65,69.05 35.12,69.58 35.12,70.1 35.26,70.23 35.43,70.23 v8(35.51,70.31) ; v8(46.28,66.71) 46.21,66.78 45.93,66.78 45.8,66.91 44.48,66.91 43.9,67.49 43.76,67.49 42.9,68.35 42.85,68.35
  IN3 w0.083: 42.85,68.35 41.12,68.35 40.97,68.51 40.97,68.77 40.89,68.84 40.67,68.84 40.62,68.79 40.62,68.51 40.46,68.35 40.11,68.35 39.94,68.51 39.94,68.77 39.87,68.84 39.67,68.84 39.6,68.77 39.6,68.51 39.44,68.35 39.09,68.35 38.93,68.51 38.93,68.8 38.88,68.84 38.64,68.84 38.58,68.79 38.58,68.51 38.42,68.35 38.07,68.35 37.93,68.49 37.93,68.66 37.85,68.73 37.67,68.73 37.59,68.66 37.59,68.48 37.46,68.35 37.08,68.35 36.94,68.49 36.74,68.49 36.59,68.35 36.33,68.35 35.66,69.01
M_0_DQSN5: length 14.4
  IN4 w0.06: v8(44.59,67.27) 43.54,67.27 43.46,67.36 42.52,67.36 41.77,68.11 41.2,68.11 41.19,68.13 41.17,68.13 ; 34.74,68.61 34.74,68.62 34.73,68.64 34.73,68.8 34.54,68.99 34.54,69.65 34.74,69.85 34.74,70.28 34.21,70.82 34.21,70.97 34.13,71.05 34.06,71.05 33.98,71.12 33.98,71.28 v8(34.01,71.31)
  IN4 w0.076: 34.74,68.61 34.74,68.39 35,68.13 38.17,68.13 38.22,68.19 38.22,68.39 38.41,68.58 38.85,68.58 38.95,68.48 39.2,68.48 39.3,68.58 39.68,68.58 39.79,68.48 40.14,68.48 40.24,68.58 40.61,68.58 41.06,68.13 41.17,68.13
M_0_DQSN6: length 23.3
  IN4 w0.06: v8(44.27,65.33) 44.09,65.33 43.95,65.19 43.36,65.19 43.28,65.26 41.45,65.26 41.17,65.54 ; v8(31.51,70.31) 31.39,70.31 31.28,70.41 30.16,70.41 29.67,69.93 29.67,69.6
  IN4 w0.076: 29.67,69.6 29.67,69.23 29.84,69.06 29.97,69.06 30.04,68.99 30.04,68.81 29.97,68.73 29.85,68.73 29.69,68.57 29.69,68.26 29.85,68.1 29.97,68.1 30.04,68.02 30.04,67.84 29.97,67.77 29.85,67.77 29.69,67.6 29.69,67.3 29.85,67.13 29.97,67.13 30.04,67.06 30.04,66.88 29.97,66.8 29.84,66.8 29.67,66.64 29.67,65.89 29.83,65.74 30.1,65.74 30.36,65.48 31.18,65.48 31.36,65.65 31.84,65.65 32.02,65.48 32.87,65.48 33.05,65.65 33.46,65.65 33.64,65.48 34.52,65.48 34.7,65.65 35.14,65.65 35.32,65.48 36.22,65.48 36.4,65.65 36.77,65.65 36.95,65.48 37.79,65.48 37.96,65.65 38.23,65.65 38.41,65.48 39.82,65.48 40,65.65 41.06,65.65 41.17,65.54
M_0_DQSN7: length 22.6
  IN3 w0.06: 31.94,69.01 31.94,69.02 31.92,69.04 31.92,69.19 31.82,69.29 31.82,69.44 32.68,70.3 33.15,70.3 33.35,70.49 33.35,71.07 33.2,71.22 33.09,71.22 v8(33.01,71.31) ; v8(46.28,65.58) 46.28,65.54 46.19,65.45 46.13,65.45 46.04,65.54 45.81,65.54 45.79,65.56 45.74,65.61 43.63,65.61 43.04,66.21 42.88,66.21 42.86,66.23 42.85,66.23
  IN3 w0.083: 42.85,66.23 34.94,66.23 34.85,66.32 34.85,66.63 34.69,66.78 34.37,66.78 34.12,66.54 33.98,66.54 33.82,66.69 33.82,66.84 34.03,67.04 34.03,67.31 33.84,67.5 33.57,67.5 33.4,67.33 33.27,67.33 33.15,67.45 32.89,67.45 32.68,67.25 32.55,67.25 32.45,67.35 32.45,67.49 32.74,67.78 32.74,68.06 32.55,68.25 32.28,68.25 31.98,67.95 31.84,67.95 31.74,68.05 31.74,68.2 31.94,68.39 31.94,69.01
M_0_DQSP0: length 22.4
  IN3 w0.06: 38.27,76.79 38.26,76.79 38.24,76.77 37.22,76.77 37.03,76.58 36.92,76.58 36.65,76.3 36.65,75.08 36.78,74.95 36.78,74.63 36.71,74.56 v8(36.26,74.56) ; v8(48.26,69.82) 48.18,69.9 48.18,69.91 48.18,70.13 48.06,70.24 48.06,71.75 48.08,71.77 48.08,71.78
  IN3 w0.083: 38.27,76.79 38.35,76.79 38.43,76.86 38.43,77.07 38.32,77.18 38.32,77.57 38.5,77.75 41.25,77.75 41.43,77.56 41.43,77.29 41.51,77.22 41.69,77.22 41.77,77.29 41.77,77.56 41.94,77.73 42.25,77.73 42.42,77.56 42.42,77.29 42.5,77.22 42.68,77.22 42.76,77.29 42.76,77.59 42.93,77.76 43.26,77.76 43.43,77.59 43.43,76.86 43.51,76.79 44.24,76.79 48.08,72.94 48.08,71.78
  BOTTOM w0.102: U23.P7 36.51,74.31 v8(36.26,74.56)
M_0_DQSP1: length 20.9
  IN4 w0.06: 38.2,75.95 38.18,75.95 38.17,75.93 37.81,75.93 37.75,75.99 v8(37.75,76.04) ; 47.98,74.12 47.98,74.1 47.96,74.09 47.96,73.46 48.08,73.34 48.08,72.44 47.92,72.28 47.92,71.32 47.98,71.26 v8(47.98,71.24)
  IN4 w0.076: 47.98,74.12 47.98,74.98 45.02,77.93 44.47,77.93 44.27,78.13 44.27,78.68 44.1,78.85 43.8,78.85 43.63,78.68 43.63,78.26 43.56,78.18 43.38,78.18 43.3,78.26 43.3,78.68 43.14,78.84 42.83,78.84 42.67,78.68 42.67,78.26 42.59,78.18 42.41,78.18 42.34,78.26 42.34,78.67 42.16,78.84 41.84,78.84 41.56,78.56 38.95,78.56 38.4,78.01 38.4,76.06 38.29,75.95 38.2,75.95
  BOTTOM w0.102: v8(37.75,76.04) 37.73,76.04 37.51,75.82 U23.T4
M_0_DQSP2: length 16.4
  IN4 w0.06: 44.94,73.95 44.95,73.94 44.95,73.91 45.11,73.75 45.11,73.21 46.06,72.26 46.06,71.77 46.12,71.71 46.22,71.71 46.28,71.77 v8(46.28,71.88) ; v8(37.48,71.81) 37.44,71.76 37.44,71.69 37.49,71.64 38.15,71.64 38.19,71.67 38.2,71.67
  IN4 w0.076: 44.94,73.95 44.43,74.45 44.22,74.45 44.17,74.5 44.17,74.72 44,74.88 43.7,74.88 43.53,74.72 43.53,74.53 43.46,74.45 43.28,74.45 43.2,74.53 43.2,75.07 43.04,75.24 42.73,75.24 42.57,75.07 42.57,74.53 42.49,74.45 42.31,74.45 42.24,74.53 42.24,74.92 42.07,75.08 41.77,75.08 41.6,74.92 41.6,74.53 41.53,74.45 41.35,74.45 41.27,74.53 41.27,74.89 41.11,75.06 40.8,75.06 40.64,74.89 40.64,74.54 40.55,74.45 40.2,74.45 39.19,73.43 39.19,72.82 38.48,72.11 38.48,71.87 38.27,71.67 38.2,71.67
M_0_DQSP3: length 14.4
  IN3 w0.06: v8(46.28,70.1) 46.2,70.19 46.2,70.47 45.99,70.68 45.99,71.04 45.33,71.71 45.33,71.73 45.28,71.78 ; 38.27,72.31 38.27,72.31 38.26,72.31 38.24,72.29 37.69,72.29 37.16,72.82 37.1,72.82 37.02,72.9 37.02,73.24 36.9,73.36 36.82,73.36 36.73,73.45 36.73,73.51 v8(36.76,73.55)
  IN3 w0.083: 38.27,72.31 38.38,72.31 38.53,72.16 38.53,72.01 38.6,71.94 38.81,71.94 38.88,72.01 38.88,72.78 39.05,72.95 39.37,72.95 39.54,72.78 39.54,72.59 39.62,72.52 39.82,72.52 39.9,72.59 39.9,73.09 40.04,73.23 43.83,73.23 45.28,71.78
  BOTTOM w0.102: U23.P9 v8(36.76,73.55)
M_0_DQSP4: length 16.2
  IN3 w0.06: 42.85,68.51 42.92,68.51 43.81,67.61 43.95,67.61 44.53,67.03 45.85,67.03 45.85,67.03 45.96,67.03 v8(46,66.99) ; v8(35.51,69.81) 35.59,69.72 35.68,69.72 35.73,69.77 35.73,70.03 35.66,70.11 35.3,70.11 35.24,70.05 35.24,69.63 35.74,69.14 35.76,69.14 35.77,69.13
  IN3 w0.083: 35.77,69.13 36.39,68.51 36.53,68.51 36.67,68.65 37.01,68.65 37.15,68.51 37.39,68.51 37.43,68.55 37.43,68.72 37.6,68.89 37.92,68.89 38.09,68.72 38.09,68.56 38.14,68.51 38.36,68.51 38.43,68.58 38.43,68.86 38.57,69 38.94,69 39.09,68.86 39.09,68.58 39.16,68.51 39.37,68.51 39.44,68.57 39.44,68.83 39.61,69 39.93,69 40.1,68.83 40.1,68.58 40.17,68.51 40.39,68.51 40.46,68.58 40.46,68.86 40.6,69 40.96,69 41.13,68.83 41.13,68.57 41.19,68.51 42.85,68.51
M_0_DQSP5: length 14.4
  IN4 w0.06: v8(44.87,66.99) 44.79,67.07 44.44,67.07 44.36,67.15 43.49,67.15 43.41,67.24 42.47,67.24 41.72,67.99 41.2,67.99 41.19,67.98 41.17,67.98 ; 34.59,68.61 34.59,68.62 34.61,68.64 34.61,68.75 34.42,68.94 34.42,69.71 34.62,69.91 34.62,70.23 34.04,70.81 v8(34.01,70.81)
  IN4 w0.076: 34.59,68.61 34.59,68.33 34.94,67.98 38.23,67.98 38.38,68.12 38.38,68.33 38.48,68.43 38.78,68.43 38.88,68.33 39.27,68.33 39.37,68.43 39.62,68.43 39.72,68.33 40.2,68.33 40.31,68.43 40.55,68.43 41,67.98 41.17,67.98
M_0_DQSP6: length 23.2
  IN4 w0.06: v8(43.95,65.58) 43.97,65.58 44.04,65.51 44.04,65.45 43.9,65.31 43.41,65.31 43.33,65.38 41.55,65.38 41.32,65.61 ; v8(31.51,69.81) 31.62,69.92 31.62,70.03 31.54,70.11 31.42,70.11 31.23,70.29 30.21,70.29 29.79,69.88 29.79,69.66 29.8,69.65 29.8,69.63 29.82,69.61 29.82,69.6
  IN4 w0.076: 41.32,65.61 41.12,65.81 39.93,65.81 39.75,65.63 38.47,65.63 38.29,65.81 37.9,65.81 37.72,65.63 37.01,65.63 36.83,65.81 36.34,65.81 36.16,65.63 35.39,65.63 35.21,65.81 34.64,65.81 34.46,65.63 33.7,65.63 33.52,65.81 32.98,65.81 32.81,65.63 32.08,65.63 31.91,65.81 31.3,65.81 31.12,65.63 30.42,65.63 30.16,65.89 29.89,65.89 29.82,65.96 29.82,66.57 29.9,66.65 30.03,66.65 30.2,66.82 30.2,67.12 30.03,67.29 29.92,67.29 29.84,67.36 29.84,67.54 29.92,67.62 30.03,67.62 30.2,67.78 30.2,68.09 30.03,68.25 29.92,68.25 29.84,68.33 29.84,68.51 29.92,68.58 30.03,68.58 30.2,68.75 30.2,69.05 30.03,69.22 29.9,69.22 29.82,69.3 29.82,69.6
M_0_DQSP7: length 22.6
  IN3 w0.06: v8(46,65.29) 46,65.38 45.97,65.41 45.78,65.41 45.69,65.49 43.58,65.49 42.99,66.09 42.87,66.09 42.85,66.07 42.85,66.07 ; 31.78,69.01 31.8,69.03 31.8,69.14 31.7,69.24 31.7,69.49 32.63,70.42 33.11,70.42 33.23,70.54 33.23,71.03 33.16,71.1 33.07,71.1 33.01,71.04 v8(33.01,70.81)
  IN3 w0.083: 31.78,69.01 31.78,68.46 31.58,68.26 31.58,67.99 31.78,67.8 32.05,67.8 32.34,68.09 32.48,68.09 32.58,67.99 32.58,67.85 32.29,67.55 32.29,67.28 32.48,67.09 32.75,67.09 32.95,67.3 33.09,67.3 33.21,67.17 33.46,67.17 33.63,67.34 33.77,67.34 33.87,67.25 33.87,67.11 33.66,66.9 33.66,66.63 33.91,66.38 34.19,66.38 34.44,66.63 34.62,66.63 34.69,66.56 34.69,66.25 34.87,66.07 42.85,66.07
M_0_ODT0: length 35
  IN2 w0.064: v12(35.38,73.57) 37.92,73.57 38,73.5 38,73.25 37.92,73.18 35.63,73.18 35.56,73.1 35.56,72.93 35.63,72.86 38.27,72.86 38.35,72.78 38.35,72.62 38.27,72.54 35.61,72.54 35.53,72.46 35.53,72.3 35.61,72.22 38.27,72.22 38.35,72.15 38.35,71.98 38.27,71.91 35.61,71.91 35.53,71.83 35.53,71.66 35.61,71.59 38.25,71.59 38.33,71.51 38.33,71.35 38.25,71.27 35.61,71.27 35.53,71.19 35.53,71.03 35.61,70.95 40.29,70.95 v12(40.69,71.35)
  IN3 w0.06: v12(35.38,73.57) v8(35.77,73.57)
  IN3 w0.064: v11(41.09,71.35) v12(40.69,71.35)
  IN4 w0.06: v8(45.15,71.88) 44.94,72.09 44.29,72.09 43.89,72.49 43.25,72.49 42.59,71.83 42.14,71.83
  IN4 w0.064: v11(41.09,71.35) 41.47,71.35 41.96,71.83 42.14,71.83
  BOTTOM w0.114: v8(35.77,73.57) 36.01,73.81 U23.N8
M_0_ODT2: length 35.5
  IN2 w0.064: v12(34.92,72.32) 34.92,68.05 35,67.97 35.16,67.97 35.24,68.05 35.24,68.91 35.32,68.99 35.48,68.99 35.56,68.91 35.56,68.05 35.63,67.97 35.8,67.97 35.87,68.05 35.87,68.91 35.95,68.99 36.12,68.99 36.19,68.91 36.19,68.05 36.27,67.97 36.43,67.97 36.51,68.05 36.51,68.91 36.59,68.99 36.75,68.99 36.83,68.91 36.83,68.05 36.9,67.97 37.07,67.97 37.14,68.05 37.14,68.91 37.22,68.99 37.39,68.99 37.46,68.91 37.46,68.05 37.54,67.97 37.7,67.97 37.78,68.05 37.78,69.01 37.86,69.09 38.02,69.09 38.1,69.01 38.1,68.05 38.17,67.97 38.34,67.97 38.41,68.05 38.41,68.91 38.49,68.99 38.66,68.99 38.73,68.91 38.73,68.05 38.81,67.97 38.97,67.97 39.05,68.05 39.05,68.91 39.13,68.99 39.29,68.99 39.37,68.91 39.37,68.05 39.44,67.97 39.61,67.97 39.68,68.05 39.68,68.91 39.76,68.99 39.93,68.99 40,68.91 40,68.05 40.08,67.97 40.24,67.97 40.32,68.05 40.32,68.91 40.4,68.99 40.59,68.99 40.66,68.91 40.66,68.45 40.74,68.38 40.97,68.38 41.04,68.45 41.04,70.87 v12(41.53,71.35)
  IN3 w0.06: v12(34.92,72.32) 34.92,72.26 34.2,71.54 v8(33.74,71.54) ; v11(41.93,71.35) 41.56,71.35
  IN3 w0.064: 41.56,71.35 v12(41.53,71.35)
  IN4 w0.06: 42.16,71.55 43.1,71.55 43.25,71.71 44.4,71.71 44.58,71.52 v8(44.87,71.52)
  IN4 w0.064: v11(41.93,71.35) 41.96,71.35 42.16,71.55
  BOTTOM w0.114: U23.H13 v8(33.74,71.54)
M_1_CA0: length 46.7
  IN2 w0.089: v12(27.61,50.93) 27.63,50.95 28.27,50.95 29.05,51.74 29.05,53.09 29.16,53.19 31.8,53.19 31.95,53.34 31.95,53.75 32.05,53.85 32.23,53.85 32.33,53.75 32.33,53.29 32.43,53.19 32.58,53.19 32.69,53.29 32.69,53.75 32.79,53.85 32.94,53.85 33.04,53.75 33.04,53.29 33.14,53.19 33.3,53.19 33.4,53.29 33.4,53.75 33.5,53.85 33.65,53.85 33.75,53.75 33.75,53.29 33.85,53.19 34.01,53.19 34.11,53.29 34.11,53.75 34.21,53.85 34.36,53.85 34.46,53.75 34.46,53.29 34.57,53.19 34.72,53.19 34.82,53.29 34.82,53.75 34.92,53.85 35.07,53.85 35.18,53.75 35.18,53.29 35.28,53.19 35.43,53.19 35.53,53.29 35.53,53.75 35.63,53.85 35.79,53.85 35.89,53.75 35.89,53.29 35.99,53.19 36.14,53.19 36.24,53.29 36.24,53.75 36.34,53.85 41.91,53.85 43.66,55.6 43.66,57.3 44.65,58.29 v12(44.65,58.62)
  IN3 w0.06: v12(44.65,58.62) 44.87,58.84 45.48,58.84 45.92,59.29 46.22,59.29 v8(46.28,59.35)
  IN3 w0.064: v8(32.01,52.66) 32.01,52.83 31.93,52.91 31.49,52.91 31.42,52.83 31.42,52.38 30.86,51.82 29.92,51.82 29.7,52.03 29.35,52.03 29.26,52.12 29.26,52.33 29.18,52.4 29.05,52.4 28.98,52.48 28.98,52.68 28.9,52.76 28.8,52.76 28.73,52.68 28.73,52.5 28.65,52.43 28.55,52.43 28.47,52.5 28.47,52.68 28.4,52.76 28.29,52.76 28.22,52.68 28.22,52.48 27.99,52.25 27.99,51.77 27.61,51.39 v11(27.61,51.33) v12(27.61,50.93) 27.14,50.93 v1(27.11,50.95)
  IN4 w0.064: v11(27.61,51.33) 27.89,51.61 27.89,55.27 29.63,57.01 30.36,57.01 v8(30.51,57.16)
M_1_CA1: length 48.4
  IN2 w0.089: v12(46.94,59.47) 46.89,59.51 45.92,59.51 45.82,59.41 45.82,59.18 45.92,59.08 46.12,59.08 46.22,58.98 46.22,58.82 46.12,58.72 45.98,58.72 45.89,58.63 45.89,55.88 41.7,51.69 41.45,51.69 41.35,51.59 41.35,51.33 40.76,50.75 30.83,50.75 29.13,49.05 28.98,49.05 28.8,49.23 28.65,49.23 28.47,49.05 28.32,49.05 28.11,49.25 27.94,49.25 27.73,49.05 27.53,49.05 26.72,49.86 26.72,52.25 26.82,52.35 27.1,52.35 27.2,52.25 27.2,51.98 27.3,51.88 27.62,51.88 v12(27.63,51.89)
  IN3 w0.06: v8(46,59.63) 46.07,59.56 46.84,59.56 v12(46.94,59.47)
  IN3 w0.064: v1(27.11,51.84) 27.16,51.89 v12(27.63,51.89) v11(27.63,52.3) 27.63,52.73 27.89,52.99 29.08,52.99 30.02,52.05 30.76,52.05 31.19,52.48 31.19,52.94 31.47,53.21 31.47,53.82 31.54,53.9 31.67,53.9 31.75,53.82 31.75,53.24 31.82,53.16 v8(32.01,53.16)
  IN4 w0.064: v11(27.63,52.3) 27.68,52.35 27.68,55.37 29.49,57.18 30.22,57.18 30.43,57.38 30.79,57.38 v8(31.01,57.16)
M_1_CA2: length 46.4
  IN2 w0.089: v12(46.6,59.1) 46.6,58.52 46.17,58.09 46.17,55.78 40.89,50.5 31.01,50.5 29.31,48.79 27.43,48.79 26.44,49.79 26.44,52.35 v12(26.82,52.73)
  IN3 w0.06: v8(46,59.07) 46.57,59.07 v12(46.6,59.1)
  IN3 w0.064: v8(32.01,53.66) 32.01,54.13 31.93,54.21 31.31,54.21 31.24,54.13 31.24,53.62 31.14,53.52 30.91,53.52 30.83,53.44 30.83,53.14 30.96,53.01 30.96,52.58 30.65,52.27 30.12,52.27 29.18,53.21 27.3,53.21 27.23,53.14 v1(27.23,52.73) v12(26.82,52.73)
  IN4 w0.064: v1(27.23,52.73) 27.48,52.99 27.48,55.48 29.41,57.41 30.07,57.41 30.2,57.53 31.14,57.53 v8(31.51,57.16)
M_1_CA3: length 49.5
  IN2 w0.089: v12(43.51,58.02) 43.1,57.61 43.1,55.75 41.7,54.36 27.25,54.36 27.15,54.26 27.15,54.1 27.25,54 28.37,54 28.47,53.9 28.47,53.75 28.37,53.65 27.28,53.65 27.17,53.54 27.17,53.39 27.28,53.29 28.34,53.29 28.44,53.19 28.44,53.04 28.34,52.94 27.33,52.94 27.23,52.83 27.23,52.68 27.33,52.58 27.91,52.58 28.06,52.43 28.06,51.69 27.91,51.54 27.23,51.54 26.97,51.28 26.97,50.32 v12(27.63,49.66)
  IN3 w0.06: v12(43.51,58.02) 43.84,58.02 44.19,58.37 44.19,58.62 44.64,59.07 v8(44.87,59.07)
  IN3 w0.064: v1(27.07,49.09) 27.07,49.1 v12(27.63,49.66) v11(27.94,49.96) 27.94,50.19 28.01,50.27 28.18,50.27 28.26,50.34 28.26,50.47 28.19,50.54 28.19,51.28 28.47,51.56 29.51,51.56 29.71,51.36 31.06,51.36 31.19,51.49 31.29,51.49 31.42,51.36 31.52,51.36 31.65,51.49 31.65,51.94 31.72,52.02 31.85,52.02 31.92,51.94 31.92,51.64 32,51.56 32.1,51.56 32.18,51.64 32.18,52 32.25,52.07 32.46,52.07 32.53,52.15 32.53,52.63 v8(32.51,52.66)
  IN4 w0.064: v8(30.51,56.66) 30.44,56.59 29.82,56.59 28.29,55.07 28.29,51.39 28.17,51.26 28.17,50.42 27.94,50.19 v11(27.94,49.96)
M_1_CA4: length 49.5
  IN2 w0.089: v12(27.61,50.29) 27.25,50.65 27.25,51.11 27.43,51.28 28.06,51.28 28.8,52.02 28.8,54 28.9,54.1 29.08,54.1 29.18,54 29.18,53.54 29.28,53.44 29.44,53.44 29.54,53.54 29.54,54 29.64,54.1 29.79,54.1 29.89,54 29.89,53.57 29.99,53.47 30.15,53.47 30.25,53.57 30.25,54 30.35,54.1 30.5,54.1 30.6,54 30.6,53.57 30.71,53.47 30.86,53.47 30.96,53.57 30.96,54 31.06,54.1 31.21,54.1 31.31,54 31.31,53.57 31.42,53.47 31.57,53.47 31.67,53.57 31.67,54 31.77,54.1 41.79,54.1 43.38,55.69 43.38,57.38 44.04,58.04 44.04,59.84 44.4,60.2 v12(44.88,60.2)
  IN3 w0.06: v8(46.57,60.2) 46.28,60.2 46.08,60.4 45.92,60.4 45.54,60.02 45.06,60.02 v12(44.88,60.2)
  IN3 w0.064: v8(32.51,53.16) 32.51,53.37 32.43,53.44 32.32,53.44 32.24,53.37 32.24,52.54 32.08,52.38 31.75,52.38 30.96,51.59 29.82,51.59 29.61,51.79 29.13,51.79 29.03,51.89 29.03,52.1 28.95,52.17 28.85,52.17 28.77,52.1 28.77,51.87 28.7,51.79 28.6,51.79 28.52,51.87 28.52,52.1 28.44,52.17 28.32,52.17 28.24,52.1 28.24,51.67 27.96,51.39 27.96,50.65 v11(27.91,50.6) v12(27.61,50.29) 27.34,50.29 v1(27.11,50.06)
  IN4 w0.064: v8(31.01,56.66) 30.76,56.91 30.44,56.91 30.35,56.82 29.77,56.82 28.09,55.14 28.09,51.51 27.96,51.39 27.96,50.65 v11(27.91,50.6)
M_1_CA5: length 48.5
  IN2 w0.089: v12(28.24,49.63) 28.7,50.09 29.38,50.09 30.55,51.26 36.27,51.26 36.37,51.36 36.37,52.22 36.47,52.33 37.08,52.33 37.18,52.43 37.18,52.96 37.28,53.06 37.44,53.06 37.54,52.96 37.54,52.43 37.64,52.33 37.8,52.33 37.9,52.43 37.9,52.95 38,53.05 38.15,53.05 38.25,52.95 38.25,52.43 38.35,52.33 38.51,52.33 38.61,52.43 38.61,52.95 38.71,53.05 38.86,53.05 38.96,52.95 38.96,52.43 39.07,52.33 39.22,52.33 39.32,52.43 39.32,52.95 39.42,53.05 39.57,53.05 39.67,52.95 39.67,52.43 39.78,52.33 39.93,52.33 40.03,52.43 40.03,52.95 40.13,53.05 40.28,53.05 40.39,52.95 40.39,52.45 40.49,52.35 40.64,52.35 40.74,52.45 40.74,52.95 40.84,53.05 41,53.05 41.1,52.95 41.1,52.45 41.2,52.35 41.35,52.35 41.45,52.45 41.45,52.95 41.55,53.05 42.33,53.05 45.28,56.01 45.28,58.65 44.98,58.95 v12(44.98,59.49)
  IN3 w0.06: v12(44.98,59.49) 45.29,59.49 v8(46,60.2)
  IN3 w0.064: v8(34.01,53.16) 34.01,52.45 32.43,50.88 32.03,50.88 31.82,50.67 30.55,50.67 29.92,50.04 v11(28.29,50.04) 28.24,49.99 v12(28.24,49.63) 27.96,49.35 v1(27.96,49.09)
  IN4 w0.064: v8(31.01,55.16) 30.61,55.16 30.38,55.4 29.82,55.4 28.9,54.48 28.9,51.36 29.08,51.18 29.08,50.83 v11(28.29,50.04)
M_1_CA6: length 48.6
  IN2 w0.089: v12(28.85,49.63) 29.28,49.63 30.65,51 36.57,51 36.66,51.09 36.66,51.44 36.77,51.54 36.92,51.54 37.02,51.44 37.02,51.09 37.11,51 37.29,51 37.37,51.09 37.37,51.33 37.48,51.44 37.63,51.44 37.73,51.33 37.73,51.09 37.82,51 38.07,51 38.17,51.11 38.17,51.92 38.27,52.02 38.43,52.02 38.53,51.92 38.53,51.11 38.63,51 38.78,51 38.88,51.11 38.88,51.94 38.99,52.05 39.14,52.05 39.24,51.94 39.24,51.11 39.34,51 39.49,51 39.6,51.11 39.6,51.92 39.7,52.02 39.85,52.02 39.95,51.92 39.95,51.11 40.05,51 40.2,51 40.31,51.11 40.31,51.94 40.41,52.05 40.56,52.05 40.66,51.94 40.66,51.41 40.76,51.31 40.92,51.31 41.02,51.41 41.02,51.91 41.11,52 41.63,52 45.54,55.91 45.54,58.98 v12(45.36,59.16)
  IN3 w0.06: v8(46.28,59.92) 45.99,59.92 45.59,59.51 45.59,59.39 v12(45.36,59.16)
  IN3 w0.064: v1(28.85,49.09) v12(28.85,49.63) v11(29.26,49.63) 29.87,49.63 30.68,50.45 31.92,50.45 32.13,50.65 32.53,50.65 34.26,52.38 34.26,53.41 v8(34.01,53.66)
  IN4 w0.064: v11(29.26,49.63) 29.31,49.68 29.31,51.23 29.11,51.44 29.11,54.31 29.71,54.92 31.14,54.92 31.38,55.16 v8(31.51,55.16)
M_1_CA7: length 46
  IN2 w0.089: v12(44.45,59.74) 44.55,59.84 45.53,59.84 45.57,59.8 47.16,59.8 47.34,59.62 47.34,56.54 41.04,50.24 39.19,50.24 39.11,50.15 39.11,49.76 39.02,49.67 38.84,49.67 38.75,49.76 38.75,50.15 38.66,50.24 38.48,50.24 38.39,50.15 38.39,49.76 38.3,49.67 38.13,49.67 38.04,49.76 38.04,50.15 37.95,50.24 37.77,50.24 37.68,50.15 37.68,49.76 37.59,49.67 37.42,49.67 37.33,49.76 37.33,50.15 37.24,50.24 37.06,50.24 36.97,50.15 36.97,49.76 36.88,49.67 36.7,49.67 36.62,49.76 36.62,50.15 36.53,50.24 36.35,50.24 36.26,50.15 36.26,49.76 36.17,49.67 35.99,49.67 35.9,49.76 35.9,50.15 35.82,50.24 35.64,50.24 35.55,50.15 35.55,49.76 35.46,49.67 35.28,49.67 35.19,49.76 35.19,50.15 35.1,50.24 34.93,50.24 34.84,50.15 34.84,49.76 34.75,49.67 34.57,49.67 34.48,49.76 34.48,50.15 34.39,50.24 31.24,50.24 30.63,49.63 v12(30.63,49.51)
  IN3 w0.06: v8(44.27,59.11) 44.27,59.56 v12(44.45,59.74)
  IN3 w0.064: v8(34.51,52.66) 34.51,50.87 34.06,50.42 32.23,50.42 32.03,50.22 30.93,50.22 v11(30.63,49.91) v12(30.63,49.51) v1(30.63,49.09)
  IN4 w0.064: v8(30.51,54.66) 30.32,54.66 30.1,54.43 29.84,54.43 29.31,53.9 29.31,51.82 30.63,50.5 v11(30.63,49.91)
M_1_CA8: length 47.5
  IN2 w0.089: v12(31.52,49.51) 31.52,48.36 31.62,48.26 31.9,48.26 32,48.36 32,48.93 32.09,49.02 32.27,49.02 32.36,48.93 32.36,48.35 32.45,48.26 32.63,48.26 32.71,48.35 32.71,49 32.82,49.1 32.97,49.1 33.07,49 33.07,48.35 33.16,48.26 33.34,48.26 33.43,48.35 33.43,49 33.53,49.1 33.68,49.1 33.78,49 33.78,48.35 33.87,48.26 34.05,48.26 34.14,48.35 34.14,48.97 34.24,49.07 34.39,49.07 34.49,48.97 34.49,48.35 34.58,48.26 34.76,48.26 34.85,48.35 34.85,48.92 34.95,49.02 35.1,49.02 35.2,48.92 35.2,48.35 35.29,48.26 39.57,48.26 39.8,48.49 39.8,49.4 40.03,49.63 41.37,49.63 47.93,56.19 47.93,59.84 47.39,60.38 v12(47.24,60.38)
  IN3 w0.06: v12(47.24,60.38) 46.85,59.99 v8(46.85,59.92)
  IN3 w0.064: v8(34.51,53.16) 34.76,52.91 34.76,51.76 34.95,51.57 34.95,50.37 34.77,50.19 32.33,50.19 32.05,49.91 v11(31.52,49.91) v12(31.52,49.51) v1(31.52,49.09)
  IN4 w0.064: v11(31.52,49.91) 29.51,51.92 29.51,53.75 29.94,54.18 30.15,54.18 30.35,54.38 30.81,54.38 31.01,54.58 v8(31.01,54.66)
M_1_CA9: length 46.6
  IN2 w0.089: v12(32.41,49.51) 32.48,49.43 35.4,49.43 35.51,49.33 35.51,48.62 35.61,48.52 35.85,48.52 35.94,48.6 35.94,49.28 36.04,49.38 36.19,49.38 36.29,49.28 36.29,48.6 36.38,48.52 36.56,48.52 36.65,48.6 36.65,49.28 36.75,49.38 36.9,49.38 37,49.28 37,48.6 37.09,48.52 37.27,48.52 37.36,48.6 37.36,49.25 37.46,49.35 37.61,49.35 37.72,49.25 37.72,48.6 37.8,48.52 39.37,48.52 39.44,48.59 39.44,49.56 39.85,49.96 41.2,49.96 47.62,56.39 47.62,59.76 47.33,60.05 45.67,60.05 45.36,60.35 v12(45.35,60.35)
  IN3 w0.06: v12(45.35,60.35) 45.36,60.35 45.5,60.48 v8(45.72,60.48)
  IN3 w0.064: v1(32.41,49.09) v12(32.41,49.51) v11(32.41,49.91) 35.51,49.91 35.58,49.99 35.58,51.74 35.51,51.82 35.07,51.82 35,51.89 35,53.17 v8(34.51,53.66)
  IN4 w0.064: v11(32.41,49.91) 30.48,51.84 29.92,51.84 29.71,52.05 29.71,53.67 29.94,53.9 31.06,53.9 31.51,54.35 v8(31.51,54.66)
M_1_CKE0: length 36.8
  IN2 w0.064: v12(41.68,57.61) 42.06,57.61 42.16,57.51 42.16,55.83 41.58,55.25 40.2,55.25 40.1,55.35 40.1,56.26 39.9,56.47 39.9,60.58 39.82,60.66 35.77,60.66 35.7,60.58 35.7,60.42 35.77,60.34 36.5,60.34 36.57,60.26 36.57,60.1 36.5,60.02 35.77,60.02 35.7,59.95 35.7,59.78 35.77,59.7 36.5,59.7 36.57,59.63 36.57,59.46 36.5,59.39 35.77,59.39 35.7,59.31 35.7,59.15 35.77,59.07 36.5,59.07 36.57,58.99 36.57,58.83 36.5,58.75 35.77,58.75 35.7,58.68 35.7,58.51 35.77,58.43 36.5,58.43 36.57,58.36 36.57,58.19 36.5,58.12 35.77,58.12 35.7,58.04 35.7,57.88 35.77,57.8 36.5,57.8 36.57,57.72 36.57,57.56 36.5,57.48 35.77,57.48 35.7,57.41 35.7,57.24 35.77,57.16 36.5,57.16 36.57,57.09 36.57,55.63 36.42,55.48 33.07,55.48 32.66,55.07 v12(32.48,55.07)
  IN3 w0.06: v8(31.01,56.16) 31.01,56.04 31.98,55.07 v12(32.48,55.07)
  IN3 w0.064: v12(41.68,57.61) v11(42.08,57.61)
  IN4 w0.064: v8(43.95,58.22) 43.03,57.3 42.39,57.3 v11(42.08,57.61)
M_1_CKE1: length 36.7
  IN2 w0.064: v12(33.17,55.07) 37.28,55.07 37.36,55.14 37.36,55.53 37.28,55.6 36.85,55.6 36.78,55.68 36.78,55.85 36.85,55.93 37.32,55.93 37.4,56.01 37.4,56.17 37.32,56.25 36.85,56.25 36.78,56.32 36.78,56.49 36.85,56.56 37.32,56.56 37.4,56.64 37.4,56.81 37.32,56.88 36.85,56.88 36.78,56.96 36.78,57.12 36.85,57.2 37.32,57.2 37.4,57.28 37.4,57.44 37.32,57.52 36.85,57.52 36.78,57.59 36.78,57.76 36.85,57.83 37.32,57.83 37.4,57.91 37.4,58.08 37.32,58.15 36.85,58.15 36.78,58.23 36.78,58.39 36.85,58.47 37.32,58.47 37.4,58.55 37.4,58.71 37.32,58.79 36.85,58.79 36.78,58.86 36.78,59.03 36.85,59.1 37.32,59.1 37.4,59.18 37.4,59.35 37.32,59.42 36.85,59.42 36.78,59.5 36.78,59.66 36.85,59.74 37.51,59.74 37.59,59.82 37.59,59.98 37.51,60.06 36.85,60.06 36.78,60.13 36.78,60.3 36.85,60.37 39.57,60.37 39.65,60.3 39.65,60.11 39.57,60.03 38.88,60.03 38.81,59.95 38.81,59.79 38.88,59.71 39.57,59.71 39.65,59.64 39.65,59.47 39.57,59.4 38.88,59.4 38.81,59.32 38.81,59.15 38.88,59.08 39.57,59.08 39.65,59 39.65,56.39 39.9,56.14 39.9,55.2 40.05,55.04 41.65,55.04 42.52,55.91 v12(42.52,56.82)
  IN3 w0.06: v12(33.17,55.07) 33.25,54.99 33.25,53.42 33.01,53.18 v8(33.01,53.16)
  IN3 w0.064: v12(42.52,56.82) v11(42.92,56.82)
  IN4 w0.06: v8(44.27,56.84) 43.91,56.84 43.73,57.02 43.51,57.02 43.3,56.82 v11(42.92,56.82)
M_1_CKE2: length 36.9
  IN2 w0.064: v12(42.52,57.61) 42.72,57.61 42.85,57.48 42.85,55.91 41.75,54.81 39.75,54.81 39.65,54.92 39.65,56.06 39.44,56.26 39.44,58.52 39.31,58.66 37.66,58.66 37.59,58.58 37.59,58.41 37.66,58.34 38.81,58.34 38.88,58.26 38.88,58.1 38.81,58.02 37.66,58.02 37.59,57.94 37.59,57.78 37.66,57.7 38.81,57.7 38.88,57.63 38.88,57.46 38.81,57.39 37.66,57.39 37.59,57.31 37.59,57.14 37.66,57.07 38.81,57.07 38.88,56.99 38.88,56.83 38.81,56.75 37.66,56.75 37.59,56.67 37.59,56.51 37.66,56.43 38.81,56.43 38.88,56.36 38.88,56.19 38.81,56.12 37.66,56.12 37.59,56.04 37.59,55.83 37.66,55.75 38.27,55.75 38.35,55.68 38.35,55.5 38.27,55.42 37.66,55.42 37.59,55.35 37.59,54.89 37.41,54.71 32.28,54.71 32,54.99 32,56.01 32.2,56.21 v12(32.41,56.21)
  IN3 w0.06: v8(31.51,56.16) 32.36,56.16 v12(32.41,56.21)
  IN3 w0.064: v12(42.52,57.61) v11(42.92,57.61)
  IN4 w0.06: v8(44.59,58.79) 44.3,58.79 44.07,58.55 43.61,58.55 42.92,57.86 v11(42.92,57.61)
M_1_CKE3: length 36.8
  IN2 w0.064: v12(40.84,57.61) 40.48,57.61 40.31,57.79 40.31,61.77 40.23,61.85 40.05,61.85 39.98,61.77 39.98,61.16 39.9,61.09 39.73,61.09 39.66,61.16 39.66,61.77 39.58,61.85 39.42,61.85 39.34,61.77 39.34,61.16 39.27,61.09 39.1,61.09 39.02,61.16 39.02,61.77 38.95,61.85 38.78,61.85 38.71,61.77 38.71,61.16 38.63,61.09 38.46,61.09 38.39,61.16 38.39,61.77 38.31,61.85 38.15,61.85 38.07,61.77 38.07,61.16 38,61.09 37.83,61.09 37.75,61.16 37.75,61.77 37.68,61.85 37.51,61.85 37.44,61.77 37.44,61.16 37.36,61.09 37.19,61.09 37.12,61.16 37.12,61.77 37.04,61.85 36.88,61.85 36.8,61.77 36.8,61.16 36.73,61.09 36.56,61.09 36.48,61.16 36.48,61.77 36.41,61.85 36.24,61.85 36.17,61.77 36.17,61.16 36.09,61.09 35.92,61.09 35.85,61.16 35.85,61.77 35.77,61.85 35.61,61.85 35.53,61.77 35.53,61.16 35.46,61.09 35.29,61.09 35.21,61.16 35.21,61.77 35.14,61.85 34.92,61.85 34.85,61.77 34.85,60.8 34.75,60.71 34.62,60.71 34.53,60.8 34.53,61.77 34.45,61.85 34.26,61.85 34.19,61.77 34.19,55.86 34.03,55.7 32.61,55.7 v12(32.48,55.58)
  IN3 w0.06: v8(33.01,53.66) 33.01,54.47 32.81,54.66 32.81,55.25 v12(32.48,55.58)
  IN3 w0.064: v11(41.25,57.61) v12(40.84,57.61)
  IN4 w0.064: v8(43.95,57.09) 43.88,57.15 41.7,57.15 v11(41.25,57.61)
M_1_CLKN0: length 33.9
  IN2 w0.083: v12(43.66,58.57) 43.66,61.85 41.29,64.22 31.43,64.22 29.02,61.81 29.02,59.27 29.39,58.9 32.62,58.9 32.93,58.58 32.93,57.86 v5(32.71,57.63) 32.71,57.41 32.18,56.88 31.76,56.88 30.7,55.82 30.7,55.44 v12(30.51,55.25)
  IN3 w0.06: v11(43.57,58.98) 43.57,58.66 v12(43.66,58.57)
  IN3 w0.083: v8(30.51,55.66) 30.51,55.66 v12(30.51,55.25)
  IN4 w0.06: v8(44.87,59.63) 44.79,59.55 44.5,59.55 44.39,59.43 44.15,59.43 44.02,59.56 43.85,59.56 43.58,59.29 43.58,58.99 v11(43.57,58.98)
M_1_CLKN2: length 33.9
  IN2 w0.083: v12(41.93,58.57) 41.93,58.65 42.03,58.75 42.21,58.75 42.29,58.68 42.29,58.21 42.22,58.14 41.57,58.14 41.32,58.39 41.32,62.41 40.04,63.69 31.73,63.69 30.5,62.45 30.5,60.36 30.82,60.04 32.27,60.04 33.65,58.66 33.65,56.94 33.32,56.62 v5(33.09,56.62) 33.12,56.59 v12(33.12,56.21)
  IN3 w0.083: v12(33.12,56.21) 33.12,56.14 33.31,55.95 33.31,55.57 33.62,55.25 33.62,53.28 v8(33.51,53.16) ; v11(42.24,58.17) 42.24,58.27 v12(41.93,58.57)
  IN4 w0.06: v11(42.24,58.17) 42.47,58.4 42.47,58.85 43.58,59.96 44.43,59.96 44.47,59.92 v8(44.59,59.92)
M_1_CLKP0: length 33.9
  IN2 w0.083: v12(43.15,58.57) 43.5,58.92 43.5,61.78 41.22,64.06 31.49,64.06 29.18,61.75 29.18,59.34 29.46,59.06 32.69,59.06 33.09,58.65 33.09,57.86 v5(33.32,57.63) 33.17,57.48 33.01,57.48 32.25,56.72 31.82,56.72 30.86,55.75 30.86,55.21 30.92,55.14 31.11,55.14 v12(31.24,55.27)
  IN3 w0.06: 31.16,55.35 v12(31.24,55.27) ; v11(43.23,58.98) 43.23,58.95
  IN3 w0.083: v12(43.15,58.57) 43.23,58.65 43.23,58.95 ; v8(31.01,55.66) 31.01,55.5 31.16,55.35
  IN4 w0.06: v11(43.23,58.98) 43.46,59.21 43.46,59.34 43.8,59.68 44.14,59.68 44.19,59.63 v8(44.3,59.63)
M_1_CLKP2: length 33.9
  IN2 w0.083: v12(33.63,56.21) 33.63,56.54 v5(33.7,56.62) 33.8,56.72 33.8,58.73 32.33,60.2 30.88,60.2 30.65,60.43 30.65,62.38 31.8,63.53 39.98,63.53 41.16,62.34 41.16,58.33 41.51,57.98 42.28,57.98 42.45,58.15 42.45,58.38 v12(42.64,58.57)
  IN3 w0.083: v12(42.64,58.57) 42.59,58.52 v11(42.59,58.17) ; v8(33.51,52.66) 33.77,52.92 33.77,55.31 33.45,55.63 33.45,55.91 33.63,56.08 v12(33.63,56.21)
  IN4 w0.06: v11(42.59,58.17) 42.59,58.8 43.63,59.84 44.38,59.84 44.5,59.72 44.67,59.72 44.87,59.92 v8(45.15,59.92)
M_1_CS0#: length 44.5
  IN2 w0.089: v12(28.52,50.67) 28.52,50.78 29.36,51.61 29.36,52.81 29.46,52.91 29.64,52.91 29.74,52.81 29.74,52.33 29.84,52.22 29.99,52.22 30.1,52.33 30.1,52.83 30.2,52.94 30.35,52.94 30.45,52.83 30.45,52.43 30.55,52.33 30.71,52.33 30.81,52.43 30.81,52.83 30.91,52.94 31.06,52.94 31.16,52.83 31.16,52.43 31.26,52.33 31.42,52.33 31.52,52.43 31.52,52.83 31.62,52.94 31.77,52.94 31.87,52.83 31.87,52.43 31.98,52.33 32.13,52.33 32.23,52.43 32.23,52.83 32.33,52.94 32.48,52.94 32.58,52.83 32.58,52.43 32.69,52.33 32.84,52.33 32.94,52.43 32.94,52.83 33.04,52.94 33.19,52.94 33.3,52.83 33.3,52.43 33.4,52.33 33.55,52.33 33.65,52.43 33.65,52.83 33.75,52.94 33.91,52.94 34.01,52.83 34.01,52.43 34.11,52.33 34.26,52.33 34.36,52.43 34.36,52.83 34.46,52.94 36.5,52.94 36.6,53.04 36.6,53.49 36.7,53.6 42.08,53.6 43.96,55.48 43.96,57.05 v12(44.32,57.41)
  IN3 w0.06: v11(44.04,57.84) 44.04,57.68 v12(44.32,57.41)
  IN3 w0.064: v8(32.51,53.66) 32.67,53.66 32.76,53.57 32.76,51.89 32.2,51.33 31.82,51.33 31.62,51.13 30.02,51.13 29.94,51.06 29.94,50.72 29.87,50.65 29.76,50.65 29.69,50.72 29.69,51.06 29.41,51.33 28.62,51.33 28.5,51.21 v11(28.5,51.08) 28.5,50.7 v12(28.52,50.67)
  IN4 w0.06: v11(44.04,57.84) 44.27,58.06 v8(44.27,58.47)
  IN4 w0.064: v11(28.5,51.08) 28.5,54.97 29.94,56.41 31.24,56.41 31.49,56.66 v8(31.51,56.66)
M_1_CS2#: length 43.4
  IN2 w0.089: v12(29.03,50.67) 29.03,50.93 29.61,51.51 30.12,51.51 30.21,51.6 30.21,52 30.3,52.08 30.48,52.08 30.57,52 30.57,51.6 30.66,51.51 30.84,51.51 30.92,51.6 30.92,52 31.01,52.08 31.19,52.08 31.28,52 31.28,51.6 31.37,51.51 31.55,51.51 31.64,51.6 31.64,52 31.72,52.08 31.9,52.08 31.99,52 31.99,51.6 32.08,51.51 32.26,51.51 32.35,51.6 32.35,52 32.44,52.08 32.61,52.08 32.7,52 32.7,51.6 32.79,51.51 32.97,51.51 33.06,51.6 33.06,52 33.15,52.08 33.32,52.08 33.41,52 33.41,51.6 33.5,51.51 33.68,51.51 33.77,51.6 33.77,52 33.86,52.08 34.04,52.08 34.12,52 34.12,51.6 34.21,51.51 34.39,51.51 34.48,51.6 34.48,52 34.57,52.08 34.75,52.08 34.84,52 34.84,51.6 34.92,51.51 35.1,51.51 35.19,51.6 35.19,52 35.28,52.08 35.46,52.08 35.55,52 35.55,51.6 35.64,51.51 35.89,51.51 36.04,51.67 36.04,52.58 36.14,52.68 36.75,52.68 36.85,52.78 36.85,53.24 36.95,53.34 42.19,53.34 44.7,55.86 v12(44.7,57.74)
  IN3 w0.06: v7(45.03,57.96) 44.93,57.96 v12(44.7,57.74)
  IN3 w0.064: v8(33.01,52.66) 33.01,51.81 32.31,51.11 31.92,51.11 31.72,50.9 30.45,50.9 29.87,50.32 29.59,50.32 29.46,50.45 29.46,50.9 29.31,51.06 v11(28.85,51.06) 28.85,50.85 v12(29.03,50.67)
  IN4 w0.06: v7(45.03,57.96) 45.03,57.38 44.93,57.28 44.93,57.03 45.08,56.88 45.08,56.72 44.95,56.59 44.66,56.59 v8(44.59,56.52)
  IN4 w0.064: v11(28.85,51.06) 28.7,51.21 28.7,54.87 29.71,55.88 30.23,55.88 v8(30.51,56.16)
M_1_DM0: length 17
  IN4 w0.06: 45.88,54.76 45.88,55.19 46.22,55.53 46.22,56.08 46.48,56.34 46.48,56.53 46.26,56.76 46.26,56.83 46,57.09 v8(46,57.37) ; v8(36.51,55.66) 36.71,55.86 36.71,56.32 37.16,56.77 38.18,56.77 38.38,56.57
  IN4 w0.064: 45.88,54.76 45.88,54.19 45.54,53.85 44.65,53.85 44.57,53.77 44.57,52.99 44.5,52.91 43.23,52.91 43.15,52.99 43.15,53.16 43.08,53.24 40.79,53.24 40.71,53.32 40.71,53.96 38.92,55.75 38.92,56.03 38.38,56.57
M_1_DM1: length 22
  IN4 w0.06: 38.38,53.67 38.2,53.67 38.05,53.82 37.49,53.82 37.32,53.66 v8(36.51,53.66) ; v8(47.7,57.37) 47.7,57.09 47.5,56.89 47.5,56.65 47.63,56.51 47.63,55.08 47.45,54.9 47.45,54.76
  IN4 w0.064: 47.45,54.76 47.45,53.09 45.36,51 45.13,51 45.06,50.93 45.06,50.75 44.98,50.67 44.87,50.67 44.8,50.75 44.8,50.94 44.72,51.02 44.62,51.02 44.54,50.94 44.54,50.75 44.47,50.67 44.37,50.67 44.29,50.75 44.29,50.94 44.21,51.02 44.11,51.02 44.04,50.94 44.04,50.75 43.96,50.67 43.86,50.67 43.78,50.75 43.78,50.94 43.71,51.02 43.6,51.02 43.53,50.94 43.53,50.75 43.45,50.67 43.35,50.67 43.27,50.75 43.27,50.94 43.2,51.02 43.1,51.02 43.02,50.94 43.02,50.75 42.94,50.67 42.84,50.67 42.77,50.75 42.77,50.94 42.69,51.02 42.59,51.02 42.51,50.94 42.51,50.75 42.44,50.67 42.33,50.67 42.26,50.75 42.26,50.94 42.18,51.02 42.08,51.02 42,50.94 42,50.75 41.93,50.67 41.83,50.67 41.75,50.75 41.75,50.94 41.67,51.02 41.57,51.02 41.5,50.94 41.5,50.75 41.42,50.67 41.3,50.67 41.22,50.75 41.22,50.9 41.14,50.98 40.69,50.98 39.14,52.53 39.14,53.24 38.71,53.67 38.38,53.67
M_1_DM2: length 20.1
  IN3 w0.06: 38.27,53.06 38.1,53.24 37.59,53.24 37.04,53.79 37.04,55.16 36.67,55.53 36.01,55.53 35.79,55.3 35.79,54.88 v8(36.01,54.66) ; v8(47.98,59.35) 47.98,59.11 47.76,58.89 47.76,58.72 47.9,58.59 47.9,58.42 47.82,58.34 47.82,56.13 47.6,55.91 47.42,55.91
  IN3 w0.064: 47.42,55.91 46.83,55.32 46.83,55.04 46,54.21 46,53.65 45.11,52.76 38.58,52.76 38.27,53.06
M_1_DM3: length 15.9
  IN3 w0.06: v8(46,58.5) 46,58.22 45.72,57.94 45.72,57.56 44.6,56.44 44.19,56.44 44.01,56.26 ; 38.27,58.17 38,58.17 37.95,58.21 37.37,58.21 37.21,58.37 36.85,58.37 36.34,58.88 36.12,58.88 35.71,58.47 35.71,58.27 36.19,57.79 36.19,57.48 v8(36.51,57.16)
  IN3 w0.064: 38.27,58.17 38.28,58.16 39.52,58.16 39.76,57.93 39.76,56.4 40.05,56.11 40.05,55.93 40.18,55.81 43.56,55.81 44.01,56.26
M_1_DM4: length 14.6
  IN3 w0.06: 43.38,60.75 43.39,60.76 43.58,60.76 44.39,61.56 45.67,61.56 v8(45.72,61.62) ; 34.52,60.45 34.48,60.42 34.48,59.81 34.36,59.69 34.24,59.69 33.98,59.44 33.98,59.31 33.51,58.84 v8(33.51,58.66)
  IN3 w0.064: 34.52,60.45 35.61,61.55 38.53,61.55 39.33,60.75 43.38,60.75
M_1_DM5: length 14.7
  IN4 w0.06: v8(44.27,61.37) 44.19,61.29 43.1,61.29 42.41,60.61 42.03,60.61 41.93,60.71 ; v8(35.01,58.66) 35.09,58.66 35.33,58.42 35.66,58.42 35.76,58.52 35.76,58.73 35.61,58.88 35.43,58.88 35.31,59 35.31,59.87 35.33,59.89 35.44,59.89 35.51,59.96 35.51,60.06 35.44,60.12 35.12,60.12 35.05,60.2 35.05,60.3 35.12,60.38 35.35,60.38 35.4,60.43 35.4,60.45
  IN4 w0.064: 41.93,60.71 41.63,60.71 41.55,60.63 41.55,60.43 41.47,60.35 41.35,60.35 41.27,60.43 41.27,60.56 41.2,60.63 40.92,60.63 40.84,60.71 40.84,60.79 40.76,60.87 40.65,60.87 40.57,60.79 40.57,60.58 40.49,60.5 40.39,60.5 40.31,60.58 40.31,60.79 40.24,60.87 39.43,60.87 39.18,61.11 35.94,61.11 35.4,60.58 35.4,60.45
M_1_DM6: length 23.3
  IN4 w0.06: v8(44.87,63.03) 44.8,63.1 44.5,63.1 44.4,63.19 43.46,63.19 43.41,63.25 42.62,63.25 42.54,63.17 42.54,63.04 42.47,62.97 42.34,62.97 42.26,63.04 42.26,63.17 42.19,63.25 42.08,63.25 42.01,63.17 42.01,63.04 41.93,62.97 41.81,62.97 41.73,63.04 41.73,63.17 41.65,63.25 41.31,63.25 41.27,63.21 41.17,63.21 ; v8(32.51,58.16) 32.51,58.45 32.08,58.88 30.88,58.88 30.76,59.01 30.76,59.72 30.43,60.05 29.84,60.05 29.7,60.19
  IN4 w0.064: 29.7,60.19 29.69,60.2 29.69,62.76 29.74,62.82 29.97,62.82 30.15,62.99 30.15,63.17 30.41,63.44 40.3,63.44 40.53,63.21 41.17,63.21
M_1_DM7: length 21.8
  IN3 w0.06: v8(45.44,63.03) 45.43,63.04 43.81,63.04 43.71,62.94 43.58,62.94 43.49,63.04 43.32,63.04 43.23,62.94 41.68,62.94 41.58,63.04 41.56,63.04 ; v8(31.51,58.67) U24.P4 31.57,58.6 31.57,58.47 31.51,58.42 31.37,58.42 31.21,58.58 31.21,58.72 31.39,58.9 32.03,58.9 32.1,58.98 32.1,59.08 32.03,59.16 31.42,59.16 31.34,59.23 31.34,59.34 31.44,59.44 31.44,59.59 31.37,59.67 31.37,60.17 31.08,60.45
  IN3 w0.064: 31.08,60.45 31.08,60.7 31.31,60.94 31.31,61.09 31.2,61.2 31.2,61.75 31.58,62.13 31.8,62.13 31.91,62.24 31.91,62.46 32.3,62.84 32.49,62.84 32.74,63.09 32.74,63.29 32.91,63.46 33.5,63.46 33.89,63.84 39.54,63.84 39.68,63.7 39.87,63.7 40.01,63.84 40.55,63.84 40.94,63.45 40.94,63.12 41.02,63.04 41.56,63.04
M_1_DQ0: length 17.2
  IN4 w0.06: 38.38,57.79 38.3,57.79 38.2,57.89 37.89,57.89 37.79,57.79 37.72,57.79 37.61,57.89 37.31,57.89 37.23,57.81 37.23,57.43 v8(37.26,57.41) ; 44.85,55.74 44.97,55.74 45.55,56.33 45.55,56.69 v8(45.44,56.81)
  IN4 w0.064: 44.85,55.74 40.7,55.74 40.62,55.82 40.62,55.92 40.46,56.08 40.46,56.21 40.62,56.38 40.62,57.83 40.56,57.9 40.42,57.9 40.36,57.84 40.36,56.57 40.28,56.49 40.18,56.49 40.1,56.57 40.1,57.84 40.04,57.9 39.91,57.9 39.84,57.84 39.84,57.07 39.77,57 39.66,57 39.59,57.07 39.59,57.84 39.53,57.9 39.4,57.9 39.33,57.84 39.33,57.58 39.26,57.51 39.15,57.51 39.08,57.58 39.08,57.84 39.03,57.89 38.71,57.89 38.6,57.79 38.38,57.79
  BOTTOM w0.114: U24.L15 v8(37.26,57.41)
M_1_DQ1: length 17.2
  IN4 w0.06: 44.85,55.55 44.98,55.55 45.67,56.24 45.67,56.85 45.5,57.02 45.5,57.16 46,57.65 v8(46.28,57.65) ; v8(37.74,57.41) 38.05,57.41 38.23,57.59 38.38,57.59
  IN4 w0.064: 44.85,55.55 44.01,55.55 43.94,55.48 43.94,54.99 43.86,54.92 43.76,54.92 43.68,54.99 43.68,55.48 43.61,55.55 43.5,55.55 43.43,55.48 43.43,54.99 43.35,54.92 43.25,54.92 43.17,54.99 43.17,55.48 43.1,55.55 42.99,55.55 42.92,55.48 42.92,54.87 42.84,54.79 42.74,54.79 42.66,54.87 42.66,55.48 42.59,55.55 42.49,55.55 42.41,55.48 42.41,54.87 42.33,54.79 42.23,54.79 42.16,54.87 42.16,55.48 42.08,55.55 41.98,55.55 41.9,55.48 41.9,55.24 41.83,55.17 41.72,55.17 41.65,55.24 41.65,55.48 41.57,55.55 40.54,55.55 40.43,55.65 40.43,55.83 40.2,56.06 40.03,56.06 39.93,56.15 39.93,56.46 38.8,57.59 38.38,57.59
  BOTTOM w0.114: U24.L16 37.51,57.17 v8(37.74,57.41)
M_1_DQ2: length 17.3
  IN4 w0.06: 45.18,54.9 45.18,55.57 45.79,56.18 45.79,57.02 v8(45.72,57.09) ; 44.9,54.9 44.9,55.27 ; 38.38,57.4 38.24,57.4 38.1,57.25 37.89,57.25 37.82,57.18 36.95,57.18 36.19,56.41 36.09,56.41 36.01,56.5 v8(36.01,56.66)
  IN4 w0.064: 38.38,57.4 38.71,57.4 39.74,56.37 39.74,56.07 39.95,55.86 40.13,55.86 40.23,55.75 40.23,55.58 40.46,55.35 41.27,55.35 41.53,55.09 41.53,54.13 41.6,54.05 41.71,54.05 41.78,54.13 41.78,54.51 41.86,54.59 43.02,54.59 43.15,54.71 43.85,54.71 43.95,54.61 44.06,54.61 44.13,54.69 44.13,55.27 44.21,55.35 44.31,55.35 44.39,55.27 44.39,54.74 44.46,54.66 44.57,54.66 44.65,54.74 44.65,55.27 44.72,55.35 44.83,55.35 44.9,55.27 ; 44.9,54.9 44.98,54.81 45.1,54.81 45.18,54.9
M_1_DQ3: length 15.7
  IN4 w0.06: 40.99,56.75 41.25,56.49 41.58,56.49 41.65,56.41 41.65,56.26 ; 38.38,58.09 38.12,58.09 38.07,58.04 37.23,58.04 37.11,57.91 36.83,57.91 36.75,57.84 36.75,57.58 36.6,57.43 36.45,57.43 36.27,57.25 v8(36.27,56.9) ; 44.85,55.93 44.94,55.93 45.36,56.34 45.37,56.36 45.37,56.54 45.24,56.67 45.24,56.89 45.35,57.01 45.35,57.17 45.27,57.25 45.24,57.29 45.24,57.56 45.39,57.71 45.66,57.71 v8(45.72,57.65)
  IN4 w0.064: 44.85,55.93 40.89,55.93 40.81,56.01 40.81,56.11 40.89,56.19 41.58,56.19 41.65,56.26 ; 40.99,56.75 40.87,56.87 40.87,57.86 40.64,58.09 38.38,58.09
  BOTTOM w0.114: U24.K14 36.5,56.66 v8(36.27,56.9)
M_1_DQ4: length 17.1
  IN4 w0.06: 46.64,54.76 46.64,55.13 46.73,55.22 46.73,55.91 46.97,56.15 46.97,56.85 47.05,56.93 47.05,57.29 v8(47.13,57.37) ; 38.38,55.22 38.25,55.22 38.08,55.39 37.6,55.39 37.31,55.68 37.18,55.68 37.06,55.81 37.06,56.21 v8(37.26,56.41)
  IN4 w0.064: 46.64,54.76 46.64,53.84 44.94,52.14 40.66,52.14 39.91,52.88 39.91,53.68 38.38,55.22
  BOTTOM w0.114: U24.K15 v8(37.26,56.41)
M_1_DQ5: length 17.5
  IN4 w0.06: v8(37.75,56.4) 37.75,56.16 37.72,56.12 37.72,56.01 37.79,55.93 38.35,55.93 38.38,55.91 ; 46.26,54.76 46.26,55.13 46.48,55.35 46.48,55.99 46.73,56.24 46.73,56.92 46.63,57.02 46.63,57.15 47.06,57.58 47.06,57.72 46.92,57.86 46.78,57.86 46.57,57.65 v8(46.57,57.37)
  IN4 w0.064: 38.38,55.91 38.54,55.74 38.54,55.6 40.31,53.83 40.31,53.04 40.51,52.83 42.18,52.83 42.25,52.76 42.25,52.59 42.33,52.52 44.78,52.52 44.98,52.72 44.98,53.37 45.06,53.44 45.44,53.44 45.51,53.37 45.63,53.37 46.26,54 46.26,54.76
  BOTTOM w0.114: U24.K16 37.51,56.65 v8(37.75,56.4)
M_1_DQ6: length 17.6
  IN4 w0.06: v8(37.26,55.91) 37.5,55.91 37.57,55.84 37.57,55.62 37.64,55.55 37.74,55.55 37.81,55.62 37.81,55.73 37.89,55.81 38,55.81 38.07,55.73 38.07,55.6 38.26,55.41 38.31,55.41 ; 46.45,54.76 46.45,55.14 46.61,55.3 46.61,55.95 46.85,56.2 v8(46.85,57.09)
  IN4 w0.064: 46.45,54.76 46.45,53.92 45.62,53.09 45.5,53.09 45.34,53.24 45.24,53.24 45.17,53.18 45.17,53.05 45.34,52.88 45.34,52.8 44.86,52.33 42.07,52.33 42,52.4 42,52.58 41.93,52.64 41.8,52.64 41.74,52.58 41.74,52.4 41.67,52.33 41.56,52.33 41.49,52.4 41.49,52.58 41.43,52.64 41.29,52.64 41.23,52.58 41.23,52.4 41.16,52.33 40.74,52.33 40.66,52.4 40.66,52.55 40.59,52.63 40.43,52.63 40.1,52.96 40.1,53.76 38.45,55.41 38.31,55.41
  BOTTOM w0.114: v8(37.26,55.91) 37.01,56.16 U24.J15
M_1_DQ7: length 15.8
  IN4 w0.06: v8(37.51,56.16) 37.51,56.17 37.51,56.49 37.64,56.62 37.87,56.62 38.02,56.47 38.02,56.24 38.16,56.1 38.38,56.1 ; 46.07,54.76 46.07,55.13 46.35,55.41 46.35,56.04 46.6,56.29 46.6,56.69 v8(46.53,56.77)
  IN4 w0.064: 38.38,56.1 38.45,56.1 38.73,55.82 38.73,55.68 40.51,53.9 40.51,53.11 40.59,53.04 42.37,53.04 42.44,52.96 42.44,52.78 42.52,52.71 42.62,52.71 42.7,52.78 42.7,52.96 42.77,53.04 42.88,53.04 42.95,52.96 42.95,52.78 43.03,52.71 44.7,52.71 44.78,52.78 44.78,53.57 44.85,53.65 45.64,53.65 46.07,54.08 46.07,54.76
M_1_DQ8: length 22.1
  IN4 w0.06: 37.28,51.79 37.23,51.84 37.23,52.44 v8(37.01,52.66) ; v8(48.55,56.45) 48.55,56.33 48.82,56.07 48.82,55.09 49.15,54.76
  IN4 w0.064: 37.28,51.79 39.94,49.14 40.09,49.14 40.23,49.28 40.33,49.28 40.47,49.14 46.8,49.14 49.17,51.51 49.17,51.71 49.1,51.79 48.93,51.79 48.85,51.86 48.85,51.97 48.93,52.04 49.1,52.04 49.17,52.12 49.17,52.22 49.1,52.3 48.93,52.3 48.85,52.37 48.85,52.48 48.93,52.55 49.1,52.55 49.17,52.63 49.17,52.73 49.1,52.8 48.93,52.8 48.85,52.88 48.85,52.98 48.93,53.06 49.1,53.06 49.17,53.13 49.17,53.24 49.1,53.31 48.93,53.31 48.85,53.39 48.85,53.49 48.93,53.57 49.1,53.57 49.17,53.64 49.17,54.74 49.15,54.76
M_1_DQ9: length 21.8
  IN4 w0.06: v8(47.17,56.77) 47.1,56.69 47.1,56.1 46.9,55.91 46.9,55.2 46.83,55.13 46.83,54.76 ; v8(36.01,52.66) 36.01,52.53 35.93,52.45 35.77,52.45 35.7,52.53 35.7,52.97 35.35,53.31 ; 35.3,53.39 35.3,53.8 35.43,53.93 35.63,53.93 35.73,54.03 35.73,54.28 35.86,54.41 36.09,54.41 36.22,54.54 36.22,54.74 36.39,54.92 37.08,54.92 37.36,55.2 38.05,55.2 38.33,54.92 38.38,54.92
  IN4 w0.064: 46.83,54.76 46.83,53.75 46.64,53.56 46.64,53.45 46.76,53.34 46.76,53.24 46.68,53.16 46.58,53.16 46.46,53.27 46.36,53.27 46.29,53.2 46.29,53.09 46.4,52.98 46.4,52.88 46.32,52.8 46.22,52.8 46.11,52.91 46,52.91 45.93,52.84 45.93,52.73 46.04,52.62 46.04,52.52 45.96,52.44 45.86,52.44 45.75,52.55 45.64,52.55 45.57,52.48 45.57,52.37 45.68,52.26 45.68,52.16 45.6,52.08 45.5,52.08 45.39,52.19 45.28,52.19 45.03,51.94 40.56,51.94 39.71,52.8 39.71,53.61 38.4,54.92 38.38,54.92 ; 35.35,53.31 35.3,53.37 35.3,53.39
M_1_DQ10: length 21.7
  IN4 w0.06: 38.36,51.83 38.2,52 37.89,52 37.79,52.1 37.79,52.86 37.72,52.94 37.08,52.94 37.01,53.01 v8(37.01,53.16) ; v8(48.26,56.81) 48.26,56.63 48.21,56.57 48.21,56.34 48.46,56.08 48.46,54.76
  IN4 w0.064: 38.36,51.83 39.26,50.94 39.26,50.83 39.08,50.65 39.08,50.55 39.15,50.47 39.26,50.47 39.44,50.65 39.54,50.65 39.62,50.58 39.62,50.47 39.44,50.29 39.44,50.19 39.51,50.11 39.62,50.11 39.8,50.29 39.9,50.29 39.98,50.22 39.98,50.11 39.8,49.93 39.8,49.83 39.87,49.75 39.98,49.75 40.16,49.93 40.26,49.93 40.66,49.53 46.61,49.53 48.46,51.39 48.46,54.76
M_1_DQ11: length 22.5
  IN4 w0.06: 47.26,54.76 47.26,54.96 47.49,55.2 47.49,56.37 v8(47.42,56.45) ; v8(36.51,53.16) 36.7,53.16 36.78,53.08 36.78,52.96 36.7,52.88 36.32,52.88 36.24,52.96 36.24,53.82 36.32,53.9 36.85,53.9 36.98,54.03 36.98,54.46 37.39,54.87 37.64,54.87 37.77,54.74 37.77,54.31 37.84,54.23 38.38,54.23
  IN4 w0.064: 47.26,54.76 47.26,53.18 45.28,51.21 43.28,51.21 43.2,51.28 43.2,51.46 43.13,51.54 43.03,51.54 42.95,51.46 42.95,51.28 42.87,51.21 42.77,51.21 42.7,51.28 42.7,51.46 42.62,51.54 42.52,51.54 42.44,51.46 42.44,51.28 42.37,51.21 42.27,51.21 42.19,51.28 42.19,51.46 42.11,51.54 42.01,51.54 41.93,51.46 41.93,51.28 41.86,51.21 41.76,51.21 41.68,51.28 41.68,51.46 41.6,51.54 41.5,51.54 41.43,51.46 41.43,51.28 41.35,51.21 41.25,51.21 41.17,51.28 41.17,51.46 41.1,51.54 40.99,51.54 40.92,51.46 40.92,51.28 40.84,51.21 40.74,51.21 40.66,51.28 40.66,51.46 40.59,51.54 40.41,51.54 39.33,52.62 39.33,53.41 38.5,54.23 38.38,54.23
M_1_DQ12: length 21.9
  IN4 w0.06: v8(36.01,53.16) 35.79,53.38 35.79,53.8 35.91,53.93 36.12,53.93 36.24,54.05 36.24,54.31 36.34,54.41 36.75,54.41 37.39,55.04 37.97,55.04 38.38,54.64 ; 47.06,54.76 47.06,54.97 47.37,55.27 47.37,56.19 47.22,56.34 47.22,56.53 47.37,56.69 47.37,56.85 47.22,57.01 47.22,57.17 47.42,57.37 v8(47.42,57.65)
  IN4 w0.064: 47.06,54.76 47.06,53.27 45.54,51.74 45.27,51.74 45.2,51.67 45.2,51.49 45.12,51.41 45.02,51.41 44.94,51.49 44.94,51.67 44.87,51.74 44.76,51.74 44.69,51.67 44.69,51.49 44.61,51.41 44.51,51.41 44.44,51.49 44.44,51.67 44.36,51.74 44.26,51.74 44.18,51.67 44.18,51.49 44.11,51.41 44,51.41 43.93,51.49 43.93,51.67 43.85,51.74 43.75,51.74 43.67,51.67 43.67,51.49 43.6,51.41 43.49,51.41 43.42,51.49 43.42,51.67 43.34,51.74 40.48,51.74 39.52,52.71 39.52,53.52 38.4,54.64 38.38,54.64
