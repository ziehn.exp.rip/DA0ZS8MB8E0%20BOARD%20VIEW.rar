# Allegro board da0ee6mbad0-d-susan-165XL-0828.brd (continued)
## Nets (continued)
M_1_DQ46: U24.P12 U29.AY54
M_1_DQ47: U24.R14 U29.BD58
M_1_DQ48: U24.T6 U29.AV54
M_1_DQ49: U24.R5 U29.AU57
M_1_DQ50: U24.N4 U29.AN55
M_1_DQ51: U24.R6 U29.AV56
M_1_DQ52: U24.T5 U29.AU55
M_1_DQ53: U24.P6 U29.AW57
M_1_DQ54: U24.N5 U29.AN57
M_1_DQ55: U24.P5 U29.AP56
M_1_DQ56: U24.R3 U29.AP52
M_1_DQ57: U24.P2 U29.AV48
M_1_DQ58: U24.T3 U29.AR49
M_1_DQ59: U24.T2 U29.AP50
M_1_DQ60: U24.N3 U29.AU51
M_1_DQ61: U24.R2 U29.AP48
M_1_DQ62: U24.P3 U29.AT48
M_1_DQ63: U24.N2 U29.AV50
M_1_DQSN0: U24.J13 U29.BU51
M_1_DQSN1: U24.D15 U29.BU45
M_1_DQSN2: U24.G13 U29.BK44
M_1_DQSN3: U24.M15 U29.BN51
M_1_DQSN4: U24.N9 U29.AY50
M_1_DQSN5: U24.R12 U29.BB56
M_1_DQSN6: U24.N7 U29.AR57
M_1_DQSN7: U24.R4 U29.AR51
M_1_DQSP0: U24.J14 U29.BV50
M_1_DQSP1: U24.D16 U29.BT44
M_1_DQSP2: U24.G14 U29.BL43
M_1_DQSP3: U24.M16 U29.BM50
M_1_DQSP4: U24.P9 U29.BA51
M_1_DQSP5: U24.T12 U29.BA55
M_1_DQSP6: U24.P7 U29.AT58
M_1_DQSP7: U24.T4 U29.AT50
M_1_ODT0: U24.H13 U29.BV54
M_1_ODT2: U24.N8 U29.BU55
MAG_DRDY: U10.27 U35.9
MCLK: C305.2 R351.2 U34.37
MCSI_1_CLK_DN: U15.1 U29.AH10
MCSI_1_CLK_DP: U15.2 U29.AG11
MCSI_1_DATA0_DN: U17.1 U29.AM8
MCSI_1_DATA0_DP: U17.2 U29.AK9
MCSI_1_DATA1_DN: U21.1 U29.AF10
MCSI_1_DATA1_DP: U21.2 U29.AG9
MCSI_2_CLK_DN: U16.1 U29.W11
MCSI_2_CLK_DP: U16.2 U29.V12
MCSI_2_DATA_DN: U18.1 U29.AB8
MCSI_2_DATA_DP: U18.2 U29.AA9
MCSI_COMP: R64.2 U29.AF14
MDSI_A0_DN: L13.4 U29.AM4
MDSI_A0_DN_C: CN9.28 L13.3
MDSI_A0_DP: L13.1 U29.AK3
MDSI_A0_DP_C: CN9.27 L13.2
MDSI_A1_DN: L11.4 U29.AM2
MDSI_A1_DN_C: CN9.22 L11.3
MDSI_A1_DP: L11.1 U29.AN3
MDSI_A1_DP_C: CN9.21 L11.2
MDSI_A2_DN: L10.4 U29.AG5
MDSI_A2_DN_C: CN9.19 L10.3
MDSI_A2_DP: L10.1 U29.AF4
MDSI_A2_DP_C: CN9.18 L10.2
MDSI_A3_DN: L14.4 U29.AG3
MDSI_A3_DN_C: CN9.31 L14.3
MDSI_A3_DP: L14.1 U29.AH4
MDSI_A3_DP_C: CN9.30 L14.2
MDSI_A_CLKN: L12.4 U29.AE5
MDSI_A_CLKN_C: CN9.25 L12.3
MDSI_A_CLKP: L12.1 U29.AE3
MDSI_A_CLKP_C: CN9.24 L12.2
MDSI_COMP: R63.2 U29.AD12
MDSI_DDC_SCL: Q3.2 R74.2 U29.C33
MDSI_DDC_SDA: Q2.2 R73.2 U29.B34
MICVDD: C321.2 C322.1 R367.2
MICVDD_C: R367.1 U34.3
MUX_OUT_SX_S: PR53.2 U7.10
NGFF_RESET#: R235.2 R236.1 U29.G19
NGFF_RESET#_C: C163.1 CN7.67 R236.2
P1_SENSOR_INT: R217.2 U12.A7 U19.1
P2_SENSOR_INT: R219.2 U12.A8 U20.1
P_3_S_EN: PR59.1 PU3.3 PU3.4
P_RCOMP_N: R316.1 U29.BM4
P_RCOMP_P: R316.2 U29.BN3
PANEL_EN: PU5.H6 Q23.1 R669.2
PLT_CLK0_CAM1: R311.2 U29.BP8
PLT_CLK1_CAM2: R202.2 U29.BR7
PLT_CLK3_I2SMCLK: R351.1 U29.BT6
PLTRST#: CN1.23 CN2.7 PU5.K5 R172.2 U29.H20
PMIC_AGND: PR14.2 PU5.C4 PU5.D13 PU5.F3 PU5.N8 PU5.N10 PU5.N12
PMIC_FABID_0: PU5.G8 R124.2 R137.1
PMIC_FABID_1: PU5.E11 R128.2 R141.1
PMIC_INT: PR93.2 U29.E17
PMIC_INT_R: PR93.1 PU5.J6
PMIC_MEMCFG0: PU5.G9 R125.2 R138.1
PMIC_MEMCFG1: PU5.E10 R127.2 R140.1
PMIC_VBUS_DIV: PR146.1 PR147.2 PU5.E9
PMIC_VDCIN_ACOK: PR145.1 PR148.2 PU5.E8
PMU_BATTLOW#: PR89.2 U29.E23
PMU_BATTLOW#_R: PR89.1 PU5.H4
PMU_RESET_OUT_1V8#: PR26.2 U12.B3
POWER_BUTTON_I_EC: R197.1 U12.B7
POWER_BUTTON_I_EC_C: R197.2 R198.1 R199.2 SW1.5 T1.2
POWER_BUTTON_INPUT: PU5.J8 R88.2 R169.2 R198.2
POWER_BUTTON_O_EC: R169.1 U12.G9
PROCHOT#: PU5.K6 R297.1 U29.E33
PROG_SPI_CLK: CN1.41 U8.E2
PROG_SPI_CS#: CN1.42 U8.D5
PROG_SPI_IO3: CN1.40 R90.2 U5.B1 U8.B4 U8.D3
PROG_SPI_MISO: CN1.43 U8.E4
PROG_SPI_MOSI: CN1.44 U8.E3
PWR_3P3_SX_EN: PR59.2 U29.J27
PWR_SD_EN: C125.2 PQ2.2 Q11.6 R181.2
REAR_CAM_LED: TP46.1 U29.K40
RES_GYRO: C302.1 U32.14
RF_KILL: Q1.2 Q1.3 R18.2
RF_KILL#: Q1.5 U29.J19
RF_KILL#_R: CN7.8 Q1.6 R278.2
ROTATION_R: TP58.1 U29.BM12
RSMRST#: PU5.J4 R86.2 R323.2 U29.C9
RTC_XTAL_IN: C275.2 R312.1 U29.B8 Y3.1
RTC_XTAL_OUT: C288.2 R312.2 U29.C7 Y3.2
S_D_RS: PR80.1 PU5.F4
S_RCOMP_N: R314.1 U29.BT4
S_RCOMP_P: R314.2 U29.BR3
SDIO2_CLK: C368.1 U29.BU23 U36.G1
SDIO2_CMD: U29.BR23 U36.G3
SDIO2_DATA0: U29.BT22 U36.F2
SDIO2_DATA1: U29.BM24 U36.F1
SDIO2_DATA2: U29.BP22 U36.G2
SDIO2_DATA3: U29.BK24 U36.F3
SDIO3_1.8_EN#: PR70.1 U29.BN11
SDIO3_1.8_EN#_R: PR70.2 PU5.H8
SDIO3_CD: Q11.2 Q11.3 R182.2
SDIO3_CD#: CN4.9 Q11.5 R183.1 T10.1 U29.BN19
SDIO3_CLK: C128.1 CN4.5 U29.BL25
SDIO3_CMD: CN4.3 T13.1 U29.BN25
SDIO3_DATA_0: CN4.7 T14.1 U29.BP24
SDIO3_DATA_1: CN4.8 T15.1 U29.BK26
SDIO3_DATA_2: CN4.1 T11.1 U29.BJ25
SDIO3_DATA_3: CN4.2 T12.1 U29.BU25
SDIO3_PWR_EN#: PR71.1 U29.BK12
SDIO3_PWR_EN#_R: PR71.2 PU5.D2
SDIO3_RCOMP: R39.2 U29.BH26
SDWN#_R: PU5.G6 TP4.1
SEC_JTAG_EN#: CN1.5 R26.1 U3.B4 U3.D3
SENSOR_HUB_INT: Q17.2 R34.1 R335.1 U3.E4
SENSOR_HUB_INT_3P3: Q17.3 R336.1 U10.25
SENSOR_HUB_RST: Q10.2 Q10.3 R160.2
SENSOR_HUB_RST#: Q10.5 U29.BJ37
SENSOR_HUB_RST_3P3_R: C106.1 Q10.6 R75.1 R157.2 U10.7
SENSOR_HUB_WAKE: Q9.5 U29.BP14
SENSOR_HUB_WAKE#: Q9.2 Q9.3 R115.2
SENSOR_HUB_WAKE_3P3: Q9.6 R116.2 U10.10
SIM_CLK: C195.1 CN7.32 J1.5 T7.2
SIM_DATA: C187.1 CN7.34 J1.4 R257.2 T8.2
SIM_PWR: C109.2 C114.2 J1.9 L2.1
SIM_RST: C199.1 CN7.30 J1.7 T6.2
SIM_VCC: CN7.36 L2.2 R178.2 R257.1
SLP_S0IX#: PR45.2 PU5.L3 Q6.1 R69.2 R180.1 U29.J21
SLP_S3#: PU5.L5 R55.2 R179.1 U29.D22
SLP_S3#_EN: PR44.2 PR45.1 PU2.3
SLP_S4#: PU5.K7 R61.2 R173.1 U29.K20
SOC_GPIO_S5_23: R45.2 U29.J17
SOC_GPIO_S5_24: R48.2 U29.K18
SOC_GPIO_S5_25: R52.2 U29.F16
SOC_GPIO_S5_26: R54.2 U29.C15
SOC_PWRBTN#: PR92.1 U29.C23
SOC_PWRBTN#_R: PR92.2 PU5.D4
SOC_RTEST#: C291.1 CN1.34 PR3.1 R324.2 U29.D10
SOC_RTEST#_R: PR3.2 PU5.H7
SOC_SPI_CLK: R97.1 U8.B3 U29.F28
SOC_SPI_CS#: R96.2 U8.B5 U29.C27
SOC_SPI_MISO: R95.2 U8.A4 U29.K28
SOC_SPI_MOSI: R92.1 U8.A2 U29.E27
SOC_USB_OC#: R298.1 U29.F24
SOC_XTAL_IN: C293.1 R326.2 U29.AR7 Y4.1
SOC_XTAL_OUT: C294.1 R326.1 U29.AT8 Y4.3
SPI_CLK: C88.1 R97.2 U8.A1 U30.6
SPI_CS#: R72.1 R96.1 U8.D1 U30.1
SPI_MISO: R95.1 U8.C1 U30.2
SPI_MOSI: R92.2 U8.B1 U30.5
SPI_PWR_EN: D1.1 D2.1 U5.A1
SPK_LN: L23.2 U34.48
SPK_LP: L24.2 U34.1
SPK_RN: L21.2 U34.47
SPK_RP: L22.2 U34.45
SPKVDD: C308.1 C309.1 C314.1 R355.2 U34.2 U34.46
SRT_CRST#: C290.1 CN1.38 R325.2 U29.G11
STM_12M_IN: C104.1 U10.5 Y1.3
STM_12M_OUT: R152.2 U10.6
STM_12M_OUT_R: C107.1 R152.1 Y1.1
SUS_CLK_GPS: R261.2 U29.J15
SUS_CLK_WLAN: U29.F14 U36.D3
SUS_PWRDNACK: PR95.1 PU5.L4
SUS_PWRDOWNACK: PR95.2 U29.H24
SVID_ALERT#: PR51.1 U29.E30
SVID_ALERT#_R: PR51.2 PR84.2 PU5.F5
SVID_CLK: PR50.1 U29.C30
SVID_CLK_R: PR50.2 PR83.2 PU5.E4
SVID_DATA: PR52.1 R303.1 U29.B28
SVID_DATA_R: PR52.2 PR80.2 PR81.1
SYS_SHDN#: C79.1 D3.1 R87.1 SW4.5
SYSTHERM_0: C97.2 PR54.2 PR55.1 PU5.K8
SYSTHERM_1: C95.2 PR114.2 PR115.1 PU5.L7
SYSTHERM_2: C96.2 PR107.2 PR108.1 PU5.L8
THERMTRIP_B: PR96.2 PU5.J7 Q24.6
TOUCH_INT#: R305.1 U29.F22 U37.4
TOUCH_INT#_C: CN11.3 R406.1 U37.5
TOUCH_RESET#: R345.1 U29.BU15 U37.3
TOUCH_RESET#_C: CN11.2 R407.1 U37.6
TP_PROXI1_POUT: TP11.1 U10.29
UART_3_RXD: CN1.32 U29.BT14
UART_3_TXD: CN1.33 U29.BU13
UART_BT_CTS: R391.2 U29.BK38
UART_BT_CTS_C: R391.1 U36.E7
UART_BT_RTS: R392.2 U29.BU39
UART_BT_RTS_C: R392.1 U36.F7
UART_BT_RXD: R394.2 U29.BV38
UART_BT_RXD_C: R394.1 U36.F8
UART_BT_TXD: R393.2 U29.BL39
UART_BT_TXD_C: R393.1 U36.E8
UART_GPS_CTS: R266.1 U29.BR37
UART_GPS_RTS: R256.1 U29.BU37
UART_GPS_RXD: R259.1 U29.BM38
UART_GPS_TXD: R258.1 U29.BP38
USB2_DEBUG_DN: CN1.27 U4.4
USB2_DEBUG_DP: CN1.26 U4.5
USB3_REXT0: R322.2 U29.N9
USB3_REXT1: R321.2 U29.M10
USB_3G_DN: R282.1 U29.F4
USB_3G_DP: R284.1 U29.E5
USB_DCIN_IDN: CN13.7 PC27.1 R148.2 R149.2 U12.C1
USB_DCIN_IDN_EC: R150.2 U12.H6
USB_FS_DM_R: CN13.11 U11.2
USB_FS_DP_R: CN13.10 U11.1
USB_HSIC_RCOMP: R62.2 U29.T14
USB_P0_DN: U4.2 U29.C3
USB_P0_DP: U4.1 U29.D2
USB_P1_DN: R131.2 U29.E3
USB_P1_DP: R132.2 U29.D4
USB_RCOMP: R68.2 U29.H8 U29.J7
USIM_DETECT: CN7.66 J1.1 R178.1 R308.1 T9.2
USIM_DETECT_R: R308.2 R402.1 U29.E15
V_GPS_1V8: C184.2 C185.1 C186.1 R262.1 R277.2 U22.A4
V_GPS_3V3: C192.1 C198.1 C209.1 R263.1 U22.E3
V_LNA_1V8_GPS: C203.2 C211.1 L8.2 U22.D3 Y2.4
V_LNA_1V8_GPS_L: C223.1 C231.1 L8.1 U27.4
VD_VBUS_CON: PC39.1 PC40.1 PC123.2 PC136.2 PD1.1 PL21.2 PL22.2 PR41.1 PR42.1 PR145.2 PR146.2 PU7.1 PU7.24
VOLUME_DOWN: PR150.2 R25.2 R333.1 U29.BR9
VOLUME_UP: PR149.2 R226.2 R332.1 U29.BU9
VREF25: PC16.1 PU5.D9 PU5.J3 PU5.N6 PU5.N9 PU5.N13
VS_BAT_FG: PC33.2 PU1.E2 SS3.1 TP20.1
VS_BAT_R: CN10.1 CN10.2 PC132.2 PU5.K9 PU7.13 PU7.14 SS3.2 TP64.1 TP65.1 TP66.1
W_DISABLE_R#: CN7.6 R280.1
WF_IRQ_R: R395.2 U36.C8
WIFI_EN: PQ3.2 PR38.1 U12.A5
WIFI_PALDO_EN: R190.1 R191.2 U13.3 U14.C2 U36.K4
WL_DEV_EN: R396.1 U29.B24
WL_HOST_WAKE: R330.1 U29.K22 U36.F6
WLBT_1V8: C369.2 C371.1 C372.2 R187.2 R390.1 R400.2 U36.H1
WLBT_3V3: C361.2 C362.1 PC36.2 PQ4.5 PQ4.6 PQ4.7 PQ4.8 R191.1 U36.A2
WP#_FLASH: R83.1 U30.3
WWAN_OFF#: R114.1 R280.2 R306.1 U29.B16
WWAN_WAKE#: R274.1 R307.1 U29.K16
XDP_BPM0: CN1.51 R45.1
XDP_BPM1: CN1.50 R48.1
XDP_BPM2: CN1.49 R52.1
XDP_BPM3: CN1.48 R54.1
XDP_CORE_PWROK: CN1.35 R89.1
XDP_H_PRDY#: CN1.54 U29.B12
XDP_H_PREQ#: CN1.55 R328.1 U29.F12
XDP_H_TCK: CN1.56 R40.2 U29.C11
XDP_H_TDI: CN1.60 R38.2 U29.E11
XDP_H_TDO: CN1.59 R41.2 U29.J11
XDP_H_TMS: CN1.58 R46.2 U29.K12
XDP_H_TRST#: CN1.57 R50.2 U29.H12
XDP_PBI: CN1.36 R88.1
XDP_RSMRST#: CN1.37 R86.1
XDP_SLP_S0IX#: CN1.45 R69.1
XDP_SLP_S3#: CN1.47 R55.1
XDP_SLP_S4#: CN1.46 R61.1
N05827: PR100.1 PU4.3
N117237: PL2.1 PU5.L1
N117765: PL9.1 PU5.R5
N117771: PL7.1 PU5.R3
N117777: PL1.1 PU5.N1
N124100: PL11.1 PU5.R7
N128381: PL18.2 PU5.E14
N128385: PL18.1 PU5.D14
N210426: PL14.1 PU5.A12 PU5.B12
N308503: PL12.1 PU5.A8
N513330: PL17.2 PU5.G15 PU5.H14
N513406: PL17.1 PU5.J14 PU5.J15
N587789: PL13.2 PU5.P10
N9315085: PL15.2 PU5.P12 PU5.R12
N9316127: PL3.2 PU5.H1
N9316131: PL4.2 PU5.E1
N9316135: PL5.2 PU5.C1
N9316139: PL8.2 PU5.A3
N9316143: PL10.2 PU5.A5
N10435301: PR68.1 PR75.1 PU5.G4
N10438479: PR67.1 PR74.1 PU5.J2
N10505050: PC19.2 PC20.1 PR12.2 PU5.L13
N16680072: D6.1 R120.2
N16686639: C94.1 CN3.19 D4.1 F1.1
N16766415: PR4.2 PU5.E3
N16778002: PU5.H9 TP12.1
N16778585: PQ5.3 PQ6.4 PR49.2
N16783225: PC74.1 PQ10.4 PR88.1 PU6.16
N16783226: PR86.1 PR88.2
N16794593: PD4.1 PL16.1 PU5.M14 PU5.M15
N16833323: PR61.2 PU3.5
N16833546: PR57.2 PU3.8
N16863834: C297.2 PU4.5 R329.1
N35983525: R226.1 SW2.5 T18.2
N35984274: R25.1 SW3.5 T2.2
N36538649: C334.1 R379.1
N36538651: C339.1 R380.1
N36538959: C338.1 U34.12
N36538961: C335.1 U34.11
N36539010: R372.2 U34.4
N36539066: C341.1 U34.19
N36539068: C341.2 U34.18
N36539082: C342.1 U34.20
N36539084: C342.2 U34.21
N37260993: CN7.7 R284.2
N37261001: CN7.9 R282.2
N37777638: PR34.2 PR35.1 PR36.1 PR37.1
N37777761: PR24.1 SS1.1
N38078677: C137.1 CN5.19 R202.1
N38417315: CN7.48 R237.1
N38417396: CN7.23 R274.2
N38556463: CN7.41 R253.2
N38556734: CN7.46 R242.1
N38652260: CN7.25 R271.2
N39192357: R163.1 U34.44
N39319858: C215.1 L7.2 U22.E6
N39319860: C205.1 R277.1 U22.E1
N40413592: C303.1 R344.1 R350.1 U32.1
N40413621: C299.2 R338.2 U31.7 U31.8
N40413927: C145.1 C146.2 R217.1 R218.1 U19.5
N40413991: C141.2 C143.1 C144.1 U19.7
N40413993: R206.1 U19.8
N40414179: R9.1 U1.4
N40571483: C115.1 U12.J8
N40575480: R173.2 U12.J6
N41116181: R390.2 U36.B10
N41116184: TP38.1 U36.D10
N41119598: TP37.1 U36.E4
N41119599: TP34.1 U36.E3
N41122329: TP40.1 U36.J2
N41122637: TP41.1 U36.H3
N41123562: TP39.1 U36.G7
N41296642: LED3.2 R196.2
N41296646: LED3.1 Q12.3
N41297294: LED2.2 R195.2
N41297298: LED2.1 Q13.3
N41360512: C151.2 CN6.14 R311.1
N41625256: R291.2 U29.E35
N41632616: TP52.1 U29.J35
N41632617: TP53.1 U29.K36
N41632618: TP51.1 U29.K34
N41660457: TP35.1 U36.D6
N41660819: R400.1 U36.E6
N41680923: C330.2 CN11.6 R373.1
N41686100: TP31.1 U36.B6
N41686129: TP33.1 U36.C7
N41686569: TP32.1 U36.D7
N41686570: TP36.1 U36.D5
N41708105: C352.2 CN12.2 L23.1
N41708143: C353.2 CN12.1 L24.1
N41708797: C350.2 CN12.4 L21.1
N41708799: C351.2 CN12.3 L22.1
N41737727: PR69.2 PR76.1 PU5.F2
N41742707: PR23.1 SS2.1
N41769021: PU4.1 R331.1
N41804483: C116.2 J1.6
N41829139: PC58.2 PC71.2 PC73.2 PC74.2 PQ10.1 PQ10.2 PQ10.3 PR79.2 PR86.2 PU6.15
N41829157: PR99.1 PU6.3
N41829187: PC59.2 PD3.1 PL6.1 PQ10.5 PQ10.6 PQ10.7 PQ10.8
N41829227: PC86.2 PU6.4
N41829281: PD2.2 PL6.2 PU6.14
N41829291: PR87.1 PR91.2 PU6.12
N41833804: PR150.1 PU5.K11
N41833869: PR149.1 PU5.L11
N41834210: PU5.F7 TP6.1
N41858843: TP13.1 U10.45
N41989961: PC80.1 PU6.2
N42014000: R396.2 U36.D2
N42025174: C129.1 C130.1 R185.2 R186.2 U13.1
N42025192: L4.2 U13.5
N42025199: C131.1 L4.1 R188.1 R189.1
N42025284: PR43.2 R188.2 U13.4
N42027821: R294.2 U29.F34
N42057036: D2.2 R84.1
N42057039: D1.2 R91.1
N42089549: CN6.10 R222.1
N42090986: PR2.1 PU5.F6
N42091018: PR94.1 PU5.G5
N42160594: C324.2 R364.2 U33.7 U33.8
N42185424: R212.2 U2.2
N42223725: TP62.1 U34.16
N42223726: TP63.1 U34.17
N42223764: R174.1 U34.40
N42223850: PQ8.4 PR66.1
N42255362: PQ7.4 PR53.1
N42265286: CN6.1 R207.1
N42265781: C138.2 C139.1 R208.1 R219.1 U20.5
N42265815: C148.1 C149.1 C150.2 U20.7
N42265817: R225.1 U20.8
N42277903: PAD1.1 R210.1
N42282408: R179.2 U12.J7
N42282522: R180.2 U12.H5
N42286068: R172.1 U12.D2
N42332245: TP27.1 U12.E2
N42332246: TP29.1 U12.F2
N42340730: C102.1 R151.1 U11.9
N42340810: R149.1 R150.1 U11.10
N42341593: PC37.2 PC38.2 PR41.2 PR42.2
N42352593: TP44.1 Y2.1
N42360901: CN9.3 CN9.4 R53.2
N42365464: CN9.1 TP56.1
N42370028: PAD2.1 R205.1
N42406876: LED1.2 R6.2
N42406878: LED1.3 R4.2
N42457191: CN6.15 TP42.1
N42457592: Q14.6 R207.2 R215.2
N42458502: C133.1 R192.1 U14.A1 U14.B1
N42458518: C134.1 R193.2 U14.A2 U14.B2
N42478813: PQ3.3 PQ4.4 PR39.2
N42479557: Q14.2 Q14.3 R216.2
N42488414: R131.1 U11.4
N42488420: R132.1 U11.5
N42879454: C376.2 R404.2 U37.7 U37.8
N43004274: D5.1 R118.2
N43015076: PU5.K2 R114.2
N43057839: PQ12.4 PQ13.3 PR152.2
N43057847: PQ13.2 PR153.1
N43058832: R411.1 U12.E9
N43095716: Q22.2 Q23.3 R664.2
N43426773: Q24.2 Q24.3 R672.1
N66087087: CN1.19 R75.2
N66113513: PR17.2 PR18.1 PU5.P14
N66113522: PR16.2 PR19.1 PU5.A14
N66925537: PQ9.4 PR77.1
N67532838: PC5.2 PU5.D3
N67533172: PC7.1 PU5.M3
N3723389213: TP1.1 U22.D4

Pads without a net: CN1 6 20 21 53; CN3 2 15; CN5 2 7 11 16; CN7 1 10 20 21 22 24 28 29 31 35 37 38 40 42 43 44 47 49 50 52 53 54 55 56 58 59 60 61 62 63 64 65 68 69 75 76 77; CN10 3 4; CN13 21 22; HOLE13 1; J1 2 3 10; PU2 4; PU3 9; PU5 B4 D5 D6 D7 D8 D10 E5 E6 E12 F9 F10 F11 F14 H10 H11 K10 L9 M2 M9 P4; PU6 17; U3 A3 A5 C5 D2 D4 E1 E2 E3 E5; U7 4 6 7; U8 A3 A5 C5 D2 D4 E1 E5; U10 2 3 4 17 26 30 31 32 33 38 40 41 46 49; U12 A4 B4 B5 C2 D8 D9 E8 F1 F8 G1 G8 H4 H7 H8 J4 J5 J9; U19 3 6; U20 3 6; U22 C3; U23 A1 A17 D8 D11 E4 H4 J12 M9 U1 U17; U24 A1 A17 D8 D11 E4 H4 J12 M9 U1 U17; U26 A4 A6 A9 A11 AA1 AA2 AA7 AA8 AA9 AA10 AA11 AA12 AA13 AA14 AE1 AE14 AG2 AG13 AH4 AH6 AH9 AH11 B2 B13 D1 D14 H1 H2 H6 H7 H8 H9 H10 H11 H12 H13 H14 J1 J7 J8 J9 J10 J11 J12 J13 J14 K1 K3 K5 K7 K8 K9 K10 K11 K12 K13 K14 L1 L2 L3 L4 L12 L13 L14 M1 M2 M3 M5 M8 M9 M10 M12 M13 M14 N1 N2 N3 N10 N12 N13 N14 P1 P2 P3 P10 P12 P13 P14 R1 R2 R3 R5 R12 R13 R14 T1 T2 T3 T5 T12 T13 T14 U1 U2 U3 U6 U7 U10 U12 U13 U14 V1 V2 V3 V12 V13 V14 W1 W2 W3 W7 W8 W9 W10 W11 W12 W13 W14 Y1 Y3 Y6 Y7 Y8 Y9 Y10 Y11 Y12 Y13 Y14; U29 AA3 AA5 AA17 AA44 AB4 AB10 AC3 AC5 AC9 AC11 AC16 AD4 AD10 AE9 AF8 AF39 AH38 AK7 AM10 AN5 AN7 AN9 AN11 AP4 AP10 AP18 AP43 AP45 AR3 AT2 AT4 AT17 AT44 AT46 AU3 AU5 AU11 AV4 AV6 AV10 AW3 AY2 AY4 AY10 BA3 BA11 BB44 BC3 BC11 BD2 BD10 BE53 BF10 BG3 BG9 BG11 BH2 BH4 BH10 BH16 BH36 BH48 BH54 BJ3 BJ5 BJ9 BJ49 BJ53 BK4 BK8 BK10 BL9 BL35 BL55 BM54 BN5 BN9 BN55 BN57 BP4 BP12 BP54 BP56 BR13 BR17 BR35 BR55 BR57 BT10 BT40 BU5 BU7 BU11 BU35 BV4 C5 C13 C19 C21 C37 D6 D14 D36 E7 E37 E55 E57 F54 F56 G3 G15 G33 G55 G57 H2 H4 H14 H54 J3 J5 J9 J33 J37 J55 K4 K8 L3 L9 L49 L53 M2 M4 M8 M34 M48 M54 N3 N5 N11 P4 P10 R3 R53 T2 T4 T6 T8 T10 T12 T39 U3 U5 U9 V4 V8 V10 V40 W3 W5 W7 W9 Y4; U34 6 13 14; U35 8; U36 A3 A5 A6 A7 A8 B3 B4 B9 C2 C4 D1 D9 E2 H2 H4 H6 H8 H9 J3 J7; U* 1; U*#2 1; U*#3 1; U*#4 1; U*#5 1; U*#6 1

## Via types
v1: diameter 0.254, hole 0.102, IN4 to BOTTOM, 3249 vias
v2: diameter 0.254, hole 0.102, TOP to IN1, 2062 vias
v3: diameter 0.254, hole 0.102, IN1 to GND1, 2036 vias
v4: diameter 0.457, hole 0.203, GND1 to GND3, 477 vias
v5: diameter 0.254, hole 0.102, GND1 to IN2, 831 vias
v6: diameter 0.22, hole 0.102, IN3 to GND3, 463 vias
v7: diameter 0.22, hole 0.102, GND3 to IN4, 911 vias
v8: diameter 0.22, hole 0.102, IN4 to BOTTOM, 1310 vias
v9: diameter 0.508, hole 0.254, TOP to BOTTOM, 419 vias
v10: diameter 0.254, hole 0.102, IN3 to GND3, 871 vias
v11: diameter 0.254, hole 0.102, GND3 to IN4, 3125 vias
v12: diameter 0.406, hole 0.203, GND1 to GND3, 326 vias
v13: diameter 0.66, hole 0.33, TOP to BOTTOM, 82 vias
v14: diameter 0.61, hole 0.356, TOP to BOTTOM, 110 vias

## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point)
+1.8V_EMMC: length 0.9
  TOP w0.508: C8.2 v9(35.6,35.25)
  vias: v9(31.34,30.76) v9(31.98,30.76)
+1V: length 29.9
  TOP w0.381: PR63.1 PR65.1 v5(73.52,59.46)
  IN2 w0.254: v5(68.65,78.44) 68.65,77.83 v12(68.86,77.62) ; v12(52.3,74.4) 52.3,74.42 52.32,74.45 v5(52.75,74.45)
  IN2 w0.381: v5(73.52,59.46) 73.52,59.83 v4(73.58,59.89)
  IN3 w0.254: v1(52.24,74.82) 52.24,74.78 52.3,74.73 v12(52.3,74.4) ; v12(68.86,77.62) 69.01,77.78 v11(69.31,77.78)
  IN3 w0.381: v11(72.54,59.89) v4(73.58,59.89)
  IN4 w0.381: v11(69.31,77.78) 76.98,77.78 77.9,76.86 v1(78.81,76.86)
  IN4 w0.508: v9(61.21,57.71) 63.32,57.71 64.78,59.17 v1(64.92,59.17) v1(65.81,59.17) 66.53,59.89 v11(72.54,59.89)
  BOTTOM w0.254: PR84.1 80.53,76.94 79.92,76.94 79.78,77.08 PR83.1 78.76,77.08 PR81.2
  vias: v2(57.36,57.71) v2(63.75,67.97)
+1V05: length 18.6
  TOP w0.254: v9(88.69,77.88) v13(88.69,78.89)
  IN4 w0.254: v1(90.12,75.59) 87.63,75.59 86.92,74.88 86.92,72.26 86.71,72.06 84.73,72.06 84.48,71.81 84.48,67.77 84.42,67.72 84.42,65.99 84.5,65.91 v1(84.5,65.55)
  BOTTOM w0.508: v9(49.3,76.63) v13(49.3,75.85) 49.51,75.63 R292.1 R295.1
+1V05_SOC: length 2.9
  IN2 w0.254: v5(48.92,54.46) 49.26,54.46 v4(49.35,54.37)
  IN2 w0.305: v5(49.25,66.92) 49.27,66.89 v12(49.27,66.02) ; v5(49.3,64.12) v4(49.3,64.59)
  IN3 w0.254: v1(48.92,54.37) v4(49.35,54.37)
  BOTTOM w0.254: v1(49.87,66.07) 49.87,65.87 U29.AD36
  vias: v1(49.32,67.02) v1(49.32,64.16) v1(50.97,74.91) v1(50.97,74.58) v3(50.9,75.01) v3(51.23,75.01) v4(51.08,75.44) v5(50.9,75.01) v5(51.23,75.01) v10(49.32,67.02) v10(49.32,64.16) v10(50.97,74.91) v10(50.97,74.58) v11(49.32,67.02) v11(49.32,64.16) v11(50.97,74.91) v11(50.97,74.58)
+1V8: length 181.4
  TOP w0.254: v2(59.27,36.33) 59.57,36.33 59.93,36.69 R74.1 61.49,37.71 R80.1 61.35,38.61 60.61,38.61 R73.1 59.97,38.47 59.95,38.49 Q2.1 ; R183.2 v2(128.17,65.98)
  TOP w0.381: R177.2 v2(116.86,64.84)
  TOP w0.508: v9(19.38,24.43) 20.59,24.43 20.98,24.82 v2(26.29,24.82) v2(26.29,25.5) ; v9(162.71,82.55) 162.33,82.55 161.82,83.06 R187.1 ; v9(121.89,54.03) 121.38,53.52 118.77,53.52 118.44,53.19 112.42,53.19 112.06,53.55 112.06,54.87 R168.2 R170.2 113.05,54.59 v9(113.46,54.18)
  IN1 w0.254: v2(68.44,76.1) 69.54,76.1 69.85,75.8 69.85,73.48 70.81,72.52 81.58,72.52 82.47,73.41 85.75,73.41 86.46,74.12 87.27,74.12 89.43,76.28 89.43,78.26 89,78.69 87.74,78.69 v2(87.53,78.47)
  IN1 w0.381: v2(112.49,43.61) v2(112.09,43.61) 112.09,40.64 ; 23.9,80.82 24.61,81.54 28.67,81.54 29.59,82.45 46.86,82.45 50.06,79.25 v9(50.26,79.25)
  IN1 w0.508: 128.06,64.64 128.06,56.36 127.68,55.98 124.36,55.98 124.02,55.65 122.81,55.65 121.89,54.74 v9(121.89,54.03)
  IN2 w0.254: v4(69.26,51.26) 69.6,50.92 v5(69.9,50.92) ; v4(86,81.48) v5(86.36,81.13) ; v4(98.07,60.15) v5(97.63,60.15) ; v4(55.14,45.32) v5(55.57,45.32) ; v4(28.05,17.38) v5(28.05,17.82)
  IN2 w0.381: v5(95.83,47.02) 95.83,47.27 95.83,47.27 95.83,48.18 95.56,48.45 v4(94.87,48.45)
  IN3 w0.254: v11(55.14,45.75) v4(55.14,45.32) ; v4(86,81.48) 86.41,81.08 v1(86.41,78.39) ; v4(98.07,60.15) 98.07,60.3 v1(98.32,60.56) ; v1(28.05,17.81) v4(28.05,17.38) ; v4(69.26,51.26) v11(68.75,51.26) ; v11(85.75,55.48) v4(86.19,55.48)
  IN3 w0.381: v4(94.87,48.45) 95.44,48.45 v1(95.45,48.46)
  IN4 w0.254: v1(50.7,49.09) 50.7,48.29 52.47,46.51 54.38,46.51 v11(55.14,45.75) 60.07,45.75 61.49,47.17 67.23,47.17 68.75,48.69 v11(68.75,51.26) ; v1(96.29,48.46) v1(95.45,48.46) 94.39,48.46 93.54,47.61 v1(93.49,47.61) ; v11(85.75,55.48) 85.75,55.78 84.53,57 84.53,59.67 84.88,60.02 v8(84.88,60.75)
  BOTTOM w0.254: R359.2 R362.2 115.54,60.47 C319.1 ; PR112.1 98.44,61.57 PR111.1 PR110.1 PR109.1 ; R262.2 v1(28.05,17.81) ; v1(50.7,49.09) 50.44,49.34 R290.1 ; R291.1 50.49,77.97 50.49,79.02 v9(50.26,79.25) 50.8,79.78 50.8,80.5 51.08,80.79 52.58,80.79 54.81,78.55 R305.2 56.09,78.55 56.26,78.39 56.26,76.94 55.97,76.65 R303.2 ; PR96.1 v1(86.41,78.39)
  BOTTOM w0.305: v9(19.38,24.43) CN2.9
  BOTTOM w0.381: v9(113.46,54.18) 113.76,54.48 113.76,57.3 113.99,57.53 115.19,57.53 115.34,57.68 115.34,60.21 C319.1
  BOTTOM w0.508: L5.2 v9(18.4,79.91)
  vias: v2(33.42,34.4) v2(34.31,34.4) v2(54.56,51.84) v2(54.56,51.46) v2(54.56,51.06) v2(57.15,42.44) v2(57.81,42.44) v2(76.93,63.25) v2(77.47,63.25) v2(83.28,46.9) v2(85.85,55.02) v2(85.85,51.33) v2(85.82,50.9) v2(86,80.8) v2(86,76.86) v2(86.08,54.76) v2(86.38,51.33) v2(86.36,50.9) v2(87.53,82.28) v2(91.18,56.36) v2(91.26,59.13) v2(102.26,46.89) v3(85.85,55.02) v3(86.08,54.76) v5(85.85,55.02) v5(86.08,54.76) v13(54.89,53.24) v14(33.78,31.7) v14(104.16,81.99) v14(111.58,81.89)
+1V8_SOC: length 3.7
  IN2 w0.254: v12(51.48,53.24) 51.84,53.24 v5(51.89,53.24) ; v5(48.54,68.49) 48.54,68.06 v12(48.5,68.02) ; v12(50.42,59.54) 50.31,59.54 50.11,59.74 v5(50.01,59.74) ; v12(53.92,55.5) v5(53.92,55.96)
  IN3 w0.254: v12(51.48,53.24) 51.48,53.58 v1(51.33,53.72) ; v1(54,55.07) 54,55.42 v12(53.92,55.5) ; v12(50.42,59.54) 50.24,59.72 50.24,59.78 v1(50.15,59.87) ; v12(48.5,68.02) v1(48.5,68.45)
+1V8S5: length 211.4
  TOP w0.254: v2(63.14,46.22) C77.2 65.72,46.22 U5.A2
  TOP w0.305: C25.2 48.55,75.76 48.79,75.52 48.79,74.4 48.97,74.22 ; R29.1 44.22,77.24 44.01,77.45 44.01,78.48 R27.1 R26.2 44.56,80.15 44.83,80.42 49.07,80.42 49.76,79.73 49.76,78.92 49.98,78.69 50.97,78.69
  TOP w0.508: v2(44.32,74.86) v2(44.7,74.47) 48.79,70.38 v13(50.95,70.38) 51.04,70.3 R37.2 ; v9(93.14,76.25) 92.81,75.92 92.81,73.48 94.8,71.48 R134.2 R135.2 R136.2 ; v9(90.45,81.18) 90.24,80.97 90.24,76.48 90.01,76.25 v9(88.21,76.25) ; 99.97,74.45 101.6,74.45 102,74.04 v2(102,62.94) ; v2(109.98,57.25) 110.41,57.68 R166.1 ; PR20.2 v9(94.56,63.53) ; 48.97,74.22 49.02,74.17 ; 49.02,74.17 47.06,74.17 v2(46.05,75.19) v2(45.69,75.54) ; 49.02,74.17 50.47,74.17 50.97,74.68 50.97,78.69 51.28,79 v9(51.28,80.32) 51.85,80.32 R38.1 R41.1 R46.1
  IN1 w0.305: v2(48.28,78.14) 46.88,78.14 46.7,77.97 46.7,77.25 47.06,76.89 48.1,76.89 48.32,76.67 v2(48.32,75.72)
  IN1 w0.381: v2(102,62.94) 101.47,62.41 101.47,61.93 100.23,60.68 100.23,54.76 102.38,52.6 105.81,52.6 106.55,53.34 107.16,53.34 109.39,55.58 109.39,56.62 109.98,57.2 v2(109.98,57.25)
  IN3 w0.254: v7(84.2,61.47) 84.25,61.47 84.39,61.32 84.39,60.63 84.34,60.58 84.34,58.63 84.63,58.35 84.63,56.41 85.09,55.96 85.09,54.84 86.61,53.32 v1(86.61,51.16) ; v11(84.73,55.65) 84.73,55.32 v4(84.6,55.2) 84.35,55.45 v11(84.35,55.86) ; v11(77.87,62.69) 77.54,63.02 75.97,63.02 75.08,62.13 v4(75.08,61.98)
  IN3 w0.508: v1(58.77,40.21) 58.75,40.24 v1(58.04,40.24) 57.96,40.31 48.64,40.31 46.61,42.34 v9(46.53,42.34)
  IN4 w0.203: v8(84.88,61.15) 84.55,61.47 v7(84.2,61.47)
  IN4 w0.254: v1(65.97,74.96) v1(65.97,81.05) ; v1(80.69,62.69) v11(77.87,62.69)
  IN4 w0.381: v1(89.66,45.65) v1(89.66,46.13) 89.02,46.76 88.54,46.76 87.65,47.65 87.65,48.21 87.27,48.59 85.8,48.59 ; v8(84.48,60.75) 84.48,60.2 84.1,59.82
  IN4 w0.508: v9(51.28,80.32) 54.73,80.32 55.9,81.48 57.32,81.48 59.03,79.78 61.9,79.78 64.82,82.7 v1(65.97,82.7) 68.55,82.7 71.07,80.19 89.46,80.19 v9(90.45,81.18)
  BOTTOM w0.254: PU5.G1 80.75,62.75 v1(80.69,62.69) ; v1(65.97,81.05) v1(65.97,82.7)
  BOTTOM w0.508: R313.1 61.28,34.61 60.96,34.29 58.98,34.29 58.7,34.57 58.7,37.77 58.8,37.87 58.8,40.18 v1(58.77,40.21) 58.75,40.24 v1(58.04,40.24) ; v1(89.66,46.13) v1(89.66,45.65) 89.18,45.16 89.18,43.22 89.81,42.59 89.81,41.86 89.34,41.39 R333.2 R332.2 ; v9(51.28,80.32) 52.38,80.32 53.11,79.59 R298.2 R302.2
  vias: v1(85.29,49.38) v1(85.29,49.05) v1(85.62,49.43) v1(85.62,49.05) v2(57.2,46.13) v2(57.2,45.72) v2(57.2,45.34) v2(57.6,46.13) v2(57.6,45.72) v2(57.6,45.34) v2(84.05,55.02) v2(84.3,54.79) v2(94.66,69.5) v2(94.92,69.24) v2(99.36,76.1) v2(99.62,75.87) v3(84.05,55.02) v3(84.3,54.79) v3(99.36,76.1) v3(99.62,75.87) v4(86.15,49.23) v4(86.79,49.23) v4(98.42,76.05) v5(84.05,55.02) v5(84.3,54.79) v5(99.36,76.1) v5(99.62,75.87) v9(82.6,50.57) v9(83.21,50.55) v10(85.29,49.38) v10(85.29,49.05) v10(85.62,49.43) v10(85.62,49.05) v11(85.29,49.38) v11(85.29,49.05) v11(85.62,49.43) v11(85.62,49.05) v14(77.7,49.66) v14(77.7,48.95)
+1V8S5_SOC: length 6.3
  IN2 w0.254: v12(55.42,65.94) 55.54,65.94 v5(55.79,66.19) ; v12(57.81,77.88) 58.04,77.65 v5(58.04,77.45)
  IN2 w0.381: v12(61.06,70.33) 61.16,70.44 v5(61.46,70.44)
  IN3 w0.254: v12(55.42,65.94) 55.42,65.82 v1(55.65,65.59) ; v1(57.5,77.57) v12(57.81,77.88)
  IN3 w0.305: v1(61.34,70.74) 61.34,70.61 v12(61.06,70.33)
  BOTTOM w0.381: v1(57.5,77.57) 57.17,77.24 R402.2 R307.2 R306.2
  vias: v1(52.35,68.45) v1(53.45,68.45) v1(54,68.45) v2(52.09,68.59) v2(53.36,68.59) v3(52.09,68.59) v3(53.36,68.59) v5(52.09,68.59) v5(53.36,68.59) v10(52.35,68.45) v10(53.45,68.45) v10(54,68.45) v11(52.35,68.45) v11(53.45,68.45) v11(54,68.45) v12(52.78,68.45) v12(53.72,68.12)
+1V8SX: length 61.7
  TOP w0.508: PC9.1 82.41,53.3 81.35,52.25 v13(81.35,51.21) 81.35,40.51 v2(82.83,39.04) v2(82.83,38.53)
  IN2 w0.254: v5(2.14,48.92) v4(2.14,48.48)
  IN3 w0.254: v4(2.14,48.48) v11(2.63,48.48)
  IN4 w0.254: v8(84.08,60.75) 84.08,60.43 83.38,59.74 83.38,59.21
  IN4 w0.508: v11(2.63,48.48) 3.1,48.01 4.6,48.01 5.43,47.17 10.69,47.17 12.88,49.36 12.88,53.04 15.11,55.27 20.47,55.27 v9(20.72,55.02)
  BOTTOM w0.381: v9(17.85,51.61) 17.85,49.94 17.78,49.86 17.78,48.57 18.1,48.25 PR44.1 ; R216.1 18.06,42.01 19,41.07 21.97,41.07 22.35,41.45 22.35,44.38 21.99,44.73 R220.1 20.13,44.97 19.3,45.8 v1(18.69,45.8)
  BOTTOM w0.508: R230.2 21.02,55.18 20.85,55.02 v9(20.72,55.02)
  vias: v1(20.43,49.18) v2(82.24,55.02) v2(82.52,54.76) v3(82.24,55.02) v3(82.52,54.76) v4(82.7,55.17) v5(82.24,55.02) v5(82.52,54.76) v10(20.43,49.18) v10(82.6,55.6) v10(83,55.6) v11(20.43,49.18) v11(82.6,55.6) v11(83,55.6)
+1V24: length 10.8
  TOP w0.508: v9(63.12,63.63) 63.01,63.73 v13(63.01,64.42) 63.01,64.88 62.51,65.39 R70.1 R71.1
  GND3 w0.254: v8(85.28,61.15) 85.28,60.76 v12(85.3,60.73)
  BOTTOM w0.508: v9(80.72,46.64) 80.92,46.64 81.94,47.65 83.31,47.65 ; v9(63.12,63.63) 62.86,63.63 62.64,63.41 R315.2
  vias: v9(84.27,50.55) v9(84.45,51.16)
+1V24S5: length 32.3
  IN3 w0.254: v1(70.25,56.92) 70.25,56.42 69.96,56.13 69.96,55.49 71.19,54.27 75.22,54.27 75.78,54.83 76.15,54.83 77.12,53.86 77.12,52.16 79.37,49.91 v1(79.4,49.91)
  BOTTOM w0.254: R320.2 64.28,68.1 64.44,67.95 64.44,66.04 64.64,65.84 67.31,65.84 68.09,65.05 68.09,61.75 70.25,59.59 v1(70.25,56.92) ; PC70.1 80.42,48.22 v13(79.98,47.78)
  vias: v1(80.31,50.32) v1(80.36,49.91) v1(80.69,50.32) v1(80.69,49.94) v6(84.08,61.15) v7(84.08,61.15) v8(84.08,61.15) v10(80.31,50.32) v10(80.36,49.91) v10(80.69,50.32) v10(80.69,49.94) v11(80.31,50.32) v11(80.36,49.91) v11(80.69,50.32) v11(80.69,49.94)
+1V24S5_SOC: length 1.9
  IN4 w0.254: v1(62.97,68.1) 62.57,68.51 61.72,68.51 61.5,68.29 v1(61.5,68.1)
+1V24SX: length 29.9
  TOP w0.381: v5(87.07,56.41) 87.25,56.41 87.74,55.92 PC23.1 87.74,54.42 88.03,54.13 v2(88.03,52.25)
  TOP w0.508: R82.1 62.92,61.33 v13(63.65,60.61) 64.36,59.89 64.36,52.3 64.87,51.79 v2(69.44,51.79) ; R82.1 R76.1 ; R82.1 R81.1
  IN2 w0.305: v5(87.07,56.41) 86.61,56.41 v4(86.59,56.44)
  IN3 w0.305: v4(86.59,56.44) 86.53,56.39 v11(86.08,56.39)
  IN4 w0.254: v11(86.08,56.39) 85.32,57.15 85.32,58.35 84.88,58.78 84.88,59.51 85.28,59.91 v8(85.28,60.75)
  vias: v2(69.95,51.79)
+1V24SX_SOC: length 3.7
  TOP w0.254: C21.1 48.32,63.64 v5(48.24,63.57)
  TOP w0.381: v2(50.09,62.51) 48.99,62.51 48.66,62.84 C21.1
  IN2 w0.254: v12(47.98,63.88) 48.24,63.62 v5(48.24,63.57)
  IN3 w0.254: v1(47.67,64.16) 47.79,64.05 47.81,64.05 v12(47.98,63.88)
  vias: v2(61.19,60.49)
+1V_SOC: length 4.7
  IN2 w0.254: v12(50.09,68.61) 50.09,69.1 v5(50.06,69.13) ; v12(61.08,63.26) v5(61.08,62.82) ; v12(51.25,60.29) 51.25,60.25 51.15,60.16 v5(51.15,59.73) ; v12(60.63,68.96) v5(61.08,68.96) ; v12(61.11,66.35) v5(61.11,65.94)
  IN3 w0.254: v1(61.08,68.91) 61.03,68.96 v12(60.63,68.96) ; v8(50.25,68.97) 50.25,68.79 50.09,68.63 v12(50.09,68.61) ; v12(61.08,63.26) 61.09,63.27 v1(61.5,63.27) ; v1(61.53,66.37) 61.13,66.37 v12(61.11,66.35) ; v1(51.25,59.87) v12(51.25,60.29)
  BOTTOM w0.114: C286.1 61.5,66.4
  vias: v2(55.65,60.73) v9(62.58,59.51) v9(63.01,59.08)
+1VS5: length 17.4
  TOP w0.254: v5(88.67,69.45) 88.67,72.24 90.75,74.32 v9(91.39,74.32)
  TOP w0.508: v2(64.54,66.83) R78.1
  IN2 w0.254: v12(85.54,66.52) 85.67,66.52 86.36,67.21 86.74,67.21 87.55,68.02 87.55,69.06 87.93,69.45 v5(88.67,69.45)
  IN3 w0.381: v4(86.64,58.37) 86.64,58.42 v11(86.36,58.7)
  IN4 w0.381: v11(86.36,58.7) 85.75,59.31 85.75,60.07 85.68,60.14 v8(85.68,61.15)
  vias: v2(65.12,66.83) v2(86.36,58.95) v2(86.59,59.21) v2(87.83,58.04) v2(87.83,57.58) v2(88.16,58.04) v2(88.16,57.58) v3(86.36,58.95) v3(86.59,59.21) v5(86.36,58.95) v5(86.59,59.21) v6(85.28,64.75) v7(85.28,64.75) v8(85.28,64.75) v14(62.91,52.73) v14(71.8,46.92) v14(72.51,46.92) v14(93.54,77.85) v14(94.28,77.85)
+1VS5_SOC: length 0.9
  IN2 w0.254: v5(60.7,67.46) 61.01,67.46 v12(61.11,67.36)
  IN3 w0.254: v1(61.5,67.21) 61.35,67.36 v12(61.11,67.36)
  vias: v1(54.55,68.45) v1(54.82,67.97) v1(55.65,68.45) v2(54.45,68.61) v2(54.45,68.25) v2(55.09,69.09) v3(54.45,68.61) v3(54.45,68.25) v3(55.09,69.09) v5(54.45,68.61) v5(54.45,68.25) v5(55.09,69.09) v10(54.55,68.45) v10(54.82,67.97) v10(55.65,68.45) v11(54.55,68.45) v11(54.82,67.97) v11(55.65,68.45) v12(54.96,68.38) v12(55.29,68.73)
+1VSX: length 11.1
  TOP w0.508: R59.1 C72.1 C73.1 C74.1 59.22,57.77 61.16,55.83 v9(61.16,51.84)
+1VSX_S:
  vias: v1(58.7,49.05) v1(58.7,48.67) v1(59.08,49.05) v1(59.08,48.67) v1(68.73,57.68) v1(68.73,57.3) v1(69.24,57.68) v1(69.24,57.3)
+1VSX_S_SOC: length 1.3
  IN2 w0.254: v5(47.95,61.8) 47.95,61.81 v12(47.95,62.21)
  IN2 w0.305: v5(48.56,74.65) 48.76,74.86 v12(48.97,74.86)
  IN3 w0.254: v1(47.95,61.78) 47.95,62.16 v12(47.95,62.21)
  vias: v1(47.95,64.64) v1(48.22,66.07) v1(48.56,74.7) v1(48.79,74.45) v2(47.77,66.06) v3(47.77,66.06) v5(47.77,66.06) v9(53.41,49.61) v10(47.95,64.64) v10(48.22,66.07) v10(48.56,74.7) v10(48.79,74.45) v11(47.95,64.64) v11(48.22,66.07) v11(48.56,74.7) v11(48.79,74.45) v12(47.95,65.13) v12(47.95,65.69)
+1VSX_SOC: length 3.2
  IN2 w0.254: v4(55.11,62.64) 55.11,62.16 v5(55.14,62.13) ; v5(56.41,74.17) 56.66,74.17 56.77,74.07 v4(56.84,74.07)
  IN2 w0.381: v12(60.58,61.16) v5(60.58,61.7)
  IN3 w0.254: v1(56.27,73.94) 56.71,73.94 v4(56.84,74.07) 56.97,73.94 v1(57.41,73.94) ; v12(60.58,61.16) 60.68,61.16 60.73,61.21 v1(60.99,61.21)
  vias: v1(54,62.73) v1(54.55,62.73) v1(55.65,61.78) v9(52.52,51.03) v10(54,62.73) v10(54.55,62.73) v10(55.65,61.78) v11(54,62.73) v11(54.55,62.73) v11(55.65,61.78)
+2.85V_EMMC:
  vias: v9(35.1,38.66) v9(35.07,37.77) v9(35.66,37.21) v9(36.27,37.21)
+2V8_CAM: length 44.5
  IN4 w0.254: v9(21.99,55.55) 22.5,55.55 22.96,56.01 22.96,61.93 22.12,62.76 v1(21.87,62.76)
  IN4 w0.508: v9(21.99,55.55) 21.99,55.3 19.96,53.27 v9(15.26,53.27) 15.26,52.5 17.45,50.32 v9(17.45,45.9) 14.37,45.9 13.36,46.92 11.53,46.92 11.12,46.51 3.16,46.51 2.87,46.8 v1(2.13,46.8)
  BOTTOM w0.508: PU2.5 15.28,52.54 PC41.1 v9(15.26,53.27) ; R215.1 18.06,45.29 v9(17.45,45.9) ; R228.2 v9(21.99,55.55)
+2V85: length 3.6
  GND3 w0.089: 87.25,61.19 86.49,61.95 v8(86.48,61.95)
  GND3 w0.114: v1(88.39,59.74) 88.39,60.35 87.55,61.19 87.25,61.19
  IN4 w0.305: v8(86.48,61.95) v8(86.48,62.35)
  vias: v2(89.43,60.63) v2(89.68,60.4) v3(89.43,60.63) v3(89.68,60.4) v5(89.43,60.63) v5(89.68,60.4) v12(89.56,61.11) v13(49.04,34.57) v14(91.59,51.13) v14(92.3,51.13)
+3.3V_PA: length 12.4
  TOP w0.508: v5(152.85,77.17) v5(152.35,77.17) 151.79,77.73 R192.2
  IN2 w0.508: v9(161.59,76.84) 161.59,76.73 160.93,76.07 155.98,76.07 155.83,76.23 153.84,76.23 152.9,77.17 v5(152.85,77.17) v5(152.35,77.17)
  BOTTOM w0.381: U36.G9 161.19,77.22 161.57,76.84 v9(161.59,76.84)
+3V3: length 158.3
  TOP w0.254: v9(8.05,65.46) 7.91,65.6 R196.1 ; 51.1,39.5 50.7,39.09 50.7,36.48 51.2,35.97 R58.1 ; v5(73.89,49.56) 74.39,49.56 74.9,50.06 R410.1
  TOP w0.381: v9(11.05,45.29) 11.05,45.81 R7.2 ; R184.2 128.38,68.69 PQ2.1 125.88,66.19 R181.1
  TOP w0.508: v9(126.23,58.07) 126.39,58.22 R182.1 ; R184.2 129.01,68.69 129.44,69.11 v9(129.44,71.02)
  IN1 w0.254: v5(53.49,77.55) 54.1,76.94 56.71,76.94 57.68,77.91 58.19,77.91 58.49,77.6 58.49,74.12 59.02,73.59 v2(59.02,73.4) ; v5(55.27,39.73) v2(57.02,39.73)
  IN1 w0.381: v9(100.23,62.16) v9(100.83,62.16)
  IN1 w0.508: v9(146.92,73.4) 148.23,74.71 148.23,76.23 151.03,79.02 151.03,83.97 151.53,84.48 153.06,84.48 153.95,83.59 164.74,83.59 165.63,82.7 165.63,76.35 168.17,73.81 v9(168.17,73.43)
  IN2 w0.254: v5(73.89,49.56) 73.89,46.69 71.73,44.53 v4(71.73,40.79) ; v5(53.49,77.55) v4(53.49,78.16)
  IN2 w0.508: v9(19.68,25.35) 19.5,25.17 19.21,25.17 15.43,21.39 v9(15.43,16.96)
  IN3 w0.254: v12(86.99,62.84) 86.9,62.75 v8(86.48,62.75)
  IN4 w0.508: v9(146.92,73.4) 147.22,73.11 147.22,72.09 146.28,71.15 143.28,71.15 142.49,71.94 130.35,71.94 v9(129.44,71.02) ; v9(124.96,60.15) 124.13,60.15 122.4,61.88 117.08,61.88 v1(116.48,61.31)
  BOTTOM w0.305: CN2.10 19.97,24.93 19.68,25.22 v9(19.68,25.35) ; v1(116.48,61.31) R370.2
  BOTTOM w0.381: v9(115.31,54.28) 114.54,55.06 R364.1
  BOTTOM w0.508: R218.2 v9(20.76,38.56) ; R208.2 v9(15.43,16.96) ; R386.1 168.55,73.81 v9(168.17,73.43) ; 126.23,59.92 126.01,60.15 v9(124.96,60.15)
  BOTTOM w0.762: v9(129.44,71.02) 129.44,70.51 127.66,68.73 127.66,61.34 126.23,59.92 v9(126.23,58.07) 125.88,58.07 124.43,56.62 122.47,56.62 119.86,54 116.3,54 v9(116,54.31)
  vias: v1(93.29,37.72) v1(93.65,37.72) v2(50.87,48.49) v2(51.3,48.49) v2(51.76,48.49) v2(52.24,48.49) v2(53.51,39.73) v2(54.38,39.73) v2(101.24,45.49) v2(101.62,45.49) v2(102,45.52) v2(113.31,52.5) v2(113.56,52.27) v2(114.2,52.27) v2(114.45,52.5) v3(53.51,39.73) v3(54.38,39.73) v4(53.95,39.73) v4(54.84,39.73) v4(92.86,37.72) v5(53.51,39.73) v5(54.38,39.73) v9(6.55,63.78) v9(7.18,63.78) v9(18.82,40.03) v9(19.61,39.98) v9(28.04,15.42) v9(28.44,14.96) v9(47.9,42.19) v9(58.37,52.6) v10(93.29,37.72) v10(93.65,37.72) v11(93.29,37.72) v11(93.65,37.72) v13(53.36,48.67)
+3V3_LCM: length 5.2
  TOP w0.381: 54.25,41.05 55.01,41.05 55.7,40.36 55.7,37.9 55.01,37.21
  vias: v9(53.62,36.78) v9(54.23,36.78)
+3V3_LS: length 11.8
  TOP w0.381: v2(4.01,45.7) 7.24,45.7 7.98,44.95 U1.6 8.13,46.27 6.28,48.12 C3.1 R7.1
  IN1 w0.381: v2(4.01,45.7) 3.56,45.7 v2(2.56,44.69)
+3V3_NGFF:
  vias: v14(18.95,7.01) v14(19.71,7.01) v14(20.47,7.01) v14(22.17,9.65) v14(22.93,9.65) v14(23.69,9.65) v14(34.06,11.51) v14(39.14,8.21) v14(40.03,8.18)
+3V3_SD_SW: length 6.6
  TOP w0.508: C127.1 C126.2 134.11,70.96 CN4.4 ; PQ2.3 127.66,69.62 127.74,69.54 R184.1 v9(128.67,71.12)
  vias: v2(134.9,70.79) v2(135.15,71.07) v3(134.9,70.79) v3(135.15,71.07) v5(134.9,70.79) v5(135.15,71.07)
+3V3PCU: length 141.1
  TOP w0.254: LED1.1 3.62,74.19 v9(4.59,74.19) ; R199.1 v9(4.19,66.45) ; v9(99.67,72.54) R151.2
  TOP w0.381: R111.2 78.25,59.51 78.52,59.24 79.86,59.24 v5(79.98,59.36)
  TOP w0.508: HE1.1 103.44,79.83 R161.1 103.65,79.19 C108.1 D7.2 102.14,78.17 101.65,77.67 101.65,76.98 R148.1 101.03,76.24 v9(101.47,75.8) ; R171.2 113.94,54.69 v9(114.3,54.33) ; PR30.1 118.39,50.95 TP19.1 117.9,51.44 v9(117.9,52.05) ; R167.2 110.64,56.8 110.18,56.34 v5(110.18,56.26)
  IN1 w0.381: v9(101.47,75.8) 101.47,74.35 v9(99.67,72.54)
  IN1 w0.508: 152.42,83.59 152.41,83.58 152.41,82.18 153.69,80.9 153.69,78.36 154.58,77.47 154.58,75.36 154.08,74.86 151.61,74.86 150.64,73.89 150.64,71.27 148.26,68.89 129.82,68.89 127.47,66.53 v9(127.47,56.64)
  IN2 w0.381: v5(79.98,59.36) 79.98,59.08 80.26,58.8 v4(80.26,58.78)
  IN2 w0.508: v9(119.3,52.88) 119.3,53.14 118.94,53.49 118.94,54.33 118.79,54.48 118.79,55.14 118.94,55.3 118.94,57.51 118.89,57.56
  IN3 w0.254: v1(108.66,57.43) 108.66,56.95 v4(108.63,56.92) ; v4(80.26,58.78) 80.29,58.78 v11(80.59,58.47)
  IN3 w0.508: v4(109.62,56.29) 110.16,56.29 110.18,56.31 110.21,56.31 v1(110.44,56.54) ; 108.99,64.54 108.99,66.92 109.36,67.29 109.36,69.43 102.94,75.85 101.5,75.85 101.47,75.82 v9(101.47,75.8)
  IN4 w0.508: 111.4,64.37 111.63,64.59 111.63,65.48 111.05,66.07 111.05,67.18 109.62,68.61 109.62,70.56 108.78,71.41 108.18,71.41 107.87,71.72 107.87,72.89 105.73,75.03 102.23,75.03 v9(101.47,75.8)
  BOTTOM w0.508: 104.62,60.68 105.86,60.68 105.93,60.62 107.75,60.62 107.82,60.68 108.25,60.68 108.48,60.45 PR129.2 108.9,60.01 110,61.11 110,63.15 109.62,63.53 ; 104.62,60.68 102.66,60.68 102.46,60.48 v9(102.46,60.22) ; 104.62,60.68 104.42,60.48 PR116.2 ; v9(114.3,54.33) 114.3,54.08 114.86,53.52 115.31,53.52 115.8,53.04 116.91,53.04 v9(117.9,52.05) 118.74,52.88 v9(119.3,52.88) 119.83,52.88 122.83,55.88 124.74,55.88 124.84,55.98 126.81,55.98 v9(127.47,56.64)
  vias: v1(108.48,63.93) v1(108.48,63.55) v1(108.84,63.98) v1(108.86,63.65) v1(109.24,63.96) v1(109.24,63.53) v2(120.82,58.47) v2(121.05,58.19) v2(152.42,83.85) v2(152.8,83.85) v3(118.89,58.07) v3(118.89,57.68) v5(118.89,58.07) v5(118.89,57.68) v10(108.48,63.93) v10(108.48,63.55) v10(108.84,63.98) v10(108.86,63.65) v10(109.24,63.96) v10(109.24,63.53) v11(108.48,63.93) v11(108.48,63.55) v11(108.84,63.98) v11(108.86,63.65) v11(109.24,63.96) v11(109.24,63.53)
+3V3S5: length 63.7
  TOP w0.254: v2(49.55,35.97) 49.28,36.24 49.28,38.37 49.46,38.55 R669.1
  TOP w0.508: R43.2 v13(49.43,71.53) 48.69,71.53 42.87,77.34 42.87,80.04 v9(42.16,80.75)
  IN1 w0.254: v9(64.51,72.54) 64.97,73 64.97,73.58 64.61,73.94 62.81,73.94 62.62,73.75 v2(62.62,73.35)
  IN2 w0.254: v5(80.87,62.31) 80.64,62.31 80.54,62.21 v12(80.46,62.21)
  IN3 w0.06: v8(86.08,62.35) 86.08,62.66 86.65,63.23 87.45,63.23
  IN3 w0.064: 87.45,63.23 87.73,63.23 87.99,62.97 88.13,62.97 88.8,62.31 v11(88.87,62.31)
  IN3 w0.254: v8(82.48,62.75) 82.48,62.67 82.14,62.33 80.67,62.33 80.54,62.21 v12(80.46,62.21) ; v8(83.28,61.15) 83.28,60.8 v12(83.23,60.76)
  IN4 w0.254: v8(87.28,62.35) 87.28,62.45 86.99,62.75 v8(86.88,62.75)
  IN4 w0.381: v8(87.28,62.35) 87.32,62.31 v11(88.87,62.31) v1(89.38,62.31) v1(89.81,62.31)
  IN4 w0.508: 62.91,78.97 62.76,78.82 59,78.82 57.07,80.75 56.46,80.75 55.17,79.45 51.15,79.45 50.49,80.11 50.49,81.41 49.73,82.17 42.92,82.17 42.16,81.41 v9(42.16,80.75)
  BOTTOM w0.152: v8(87.28,62.35) v8(86.88,62.75)
  BOTTOM w0.508: v9(20.95,50.34) 21.36,50.75 PC43.1 20.81,52.95 20.4,52.54 PU2.1
  vias: v1(64.92,66.41) v1(66.95,66.41) v1(107.57,62.71) v1(107.62,62.21) v1(107.85,62.46) v1(108.15,62.71) v1(108.15,62.23) v1(108.61,62.23) v1(108.66,62.74) v1(109.14,62.69) v1(109.06,62.23) v2(83.33,61.27) v2(83.59,61.04) v3(83.33,61.27) v3(83.59,61.04) v5(83.33,61.27) v5(83.59,61.04) v14(98.29,50.85) v14(98.29,50.14)
+3V3S5_SOC: length 0.9
  IN2 w0.305: v12(54.56,69.19) 54.56,69.37 54.51,69.42 v5(54.51,69.62)
  IN3 w0.305: v12(54.56,69.19) 54.34,68.97 v1(54.21,68.97)
+3V3SX:
  vias: v1(63.7,68.86) v1(63.93,69.11) v1(65.6,68.68) v1(66.27,68.71) v10(63.7,68.86) v10(63.93,69.11) v10(65.6,68.68) v10(66.27,68.71) v11(63.7,68.86) v11(63.93,69.11) v11(65.6,68.68) v11(66.27,68.71)
+3VPCU_EC: length 15.6
  TOP w0.254: 116.07,59.84 U12.E6 v2(115.6,60.34) ; 116.07,59.84 116.07,60.32 U12.F5 ; 116.07,59.84 116.1,59.82 v2(116.1,59.34) v2(116.6,59.34)
  TOP w0.305: C119.1 v2(115.97,63.5)
  TOP w0.508: R164.2 110.31,63.3 111.6,62 C110.2 111.69,61.94 C112.1 C113.1 ; L3.1 120.93,54.18 119.61,54.18 119.4,54.38 v9(119.4,54.81) ; C118.1 115.59,55.95 v9(116.05,56.4) 116.48,55.97 C120.1
  BOTTOM w0.508: v9(119.4,54.81) 117.64,54.81 v9(116.05,56.4)
  vias: v2(111.68,60.86) v2(111.68,59.97)
+3VPCU_EC_PWR: length 14
  TOP w0.305: v5(117.07,60.5) 117.07,60.45 116.96,60.34 U12.F4
  TOP w0.508: v9(119.3,59.72) 119.3,58.93 119.91,58.32 R408.1 120.12,59.42 C123.2 120.16,59.92 120.12,59.96 C121.1
  IN2 w0.305: v5(117.07,60.5) 117.07,60.45 116.99,60.38 v4(116.99,60.07)
  IN3 w0.305: v4(116.99,60.07) v11(116.99,60.61)
  IN4 w0.508: v9(119.3,59.72) 118.41,60.61 v11(116.99,60.61) 115.31,60.61 112.77,63.15 112.44,63.15
  vias: v2(109.93,65.15) v2(110.11,64.87) v2(110.31,65.15) v2(110.46,64.85) v2(110.51,64.42) v3(109.93,65.15) v3(110.11,64.87) v3(110.31,65.15) v3(110.46,64.85) v3(110.51,64.42) v4(111.78,64.67) v4(111.78,64.14) v5(109.93,65.15) v5(110.11,64.87) v5(110.31,65.15) v5(110.46,64.85) v5(110.51,64.42) v10(111.91,63.68) v10(111.91,63.35) v10(112.24,63.68) v10(112.24,63.35) v11(111.91,63.68) v11(111.91,63.35) v11(112.24,63.68) v11(112.24,63.35)
+5V: length 28.7
  TOP w0.254: v2(72.32,55.91) C87.2 73.31,55.9 U7.8
  TOP w0.508: v2(87.02,68.07) 87.02,71.05
  IN1 w1.016: 98.9,54.79 99.36,55.25 99.36,70.69 102.33,73.66 102.33,76.73
  vias: v1(111.4,78.64) v1(111.91,78.64) v1(118.26,61.28) v2(87.02,71.68) v2(87.02,71.32) v2(98.5,54.46) v2(98.5,54.1) v2(98.52,53.75) v2(98.83,54.46) v2(98.88,54.13) v2(98.85,53.77) v2(153.82,76.23) v2(154.07,76.48) v3(101.85,78.56) v3(101.85,78.23) v3(101.85,77.9) v3(102.21,78.56) v3(102.21,78.23) v3(102.21,77.9) v3(111.4,78.39) v3(111.78,78.39) v3(118.36,60.99) v4(111.5,79.07) v4(112.04,79.15) v4(117.83,61.14) v5(101.85,78.56) v5(101.85,78.23) v5(101.85,77.9) v5(102.21,78.56) v5(102.21,78.23) v5(102.21,77.9) v5(111.4,78.39) v5(111.78,78.39) v5(118.36,60.99) v10(111.4,78.64) v10(111.91,78.64) v10(118.26,61.28) v11(111.4,78.64) v11(111.91,78.64) v11(118.26,61.28) v13(98.83,52.73) v14(98.37,77.7) v14(98.37,76.94)
+5V_SRC: length 2.4
  IN4 w0.06: 86.08,64.75 86.28,64.55 86.99,64.55
  IN4 w0.076: 87.96,64.62 87.68,64.62 87.6,64.55 86.99,64.55 ; v8(86.08,64.75) 86.08,64.75
  IN4 w0.127: 87.96,64.62 v1(88.24,64.9)
  vias: v1(96.92,65.18) v1(96.92,64.67) v1(97.43,65.18) v1(97.43,64.67) v9(96.67,54.89) v9(96.67,53.49)
+A3VPCU: length 5
  TOP w0.254: U12.B1 118.24,58.34 119.15,57.43 C122.1
  TOP w0.508: C122.1 120.12,56.96 120.16,56.92 C124.1 L3.2
+V1.0S_GPIO: length 55.9
  IN2 w0.508: v4(85.98,52.5) 86.11,52.5 93.02,59.41 98.68,59.41 100.55,61.29 101.49,61.29 101.65,61.44
  IN3 w0.508: v11(74.58,55.03) v11(75.19,55.03) 75.32,55.03 75.59,55.3 76.35,55.3 77.59,54.05 77.59,52.38 79.88,50.09 79.88,49.61 80.08,49.4 81,49.4 81.33,49.73 81.33,50.36 82.87,51.91 85.38,51.91 v4(85.98,52.5)
  IN4 w0.508: 60.83,60.22 64.33,60.22 64.61,60.5 74.01,60.5 74.52,60 74.52,55.09 v11(74.58,55.03) v11(75.19,55.03)
  vias: v1(55.65,60.83) v1(55.92,60.35) v1(60.02,60.61) v1(60.14,59.18) v1(60.19,60.89) v1(60.37,60.61) v1(60.47,59.18) v1(60.8,59.18) v2(55.65,60.02) v2(55.78,60.33) v2(101.76,61.57) v2(102.18,61.57) v3(55.65,60.02) v3(55.78,60.33) v3(101.76,61.57) v3(102.18,61.57) v5(55.65,60.02) v5(55.78,60.33) v5(101.76,61.57) v5(102.18,61.57) v9(60.17,59.67) v9(60.78,59.65) v10(55.65,60.83) v10(55.92,60.35) v11(55.65,60.83) v11(55.92,60.35) v12(56.13,60.71) v12(56.07,59.97)
+V1.0S_GUIO: length 1
  IN2 w0.254: v12(56.11,68.63) 56.08,68.63 v5(55.72,68.99)
  IN3 w0.254: v12(56.11,68.63) 55.9,68.83 v8(55.9,68.97)
+V1.0SX_DIGDP: length 0.4
  IN2 w0.254: v5(55.85,62.14) 55.88,62.14 55.9,62.12 56.09,61.93 v12(56.21,61.93)
  vias: v1(55.92,62.26) v10(55.92,62.26) v11(55.92,62.26)
+V1.8S_2M_F: length 4.8
  TOP w0.508: v9(3.86,47.33) 3.79,47.27 C2.1 C1.1 R1.1
  BOTTOM w0.305: CN5.20 4.95,47.12 4.73,47.33 v9(3.86,47.33)
+V1.8U_LPDDR3: length 25.3
  IN2 w0.254: v12(37.3,51.87) v5(37.72,51.87) ; v12(37.92,69.72) 38.25,69.72 v5(38.33,69.65) ; v5(26.11,75.72) v4(26.54,75.72) ; v5(38.43,59.74) v12(37.94,59.74) ; v5(38.35,77.09) 38.3,77.14 v12(37.92,77.14) ; v4(29.99,65.91) v5(29.99,65.46) ; v5(26.23,53.62) v4(26.67,53.62) ; v5(29.99,63.98) v4(29.99,63.55)
  IN3 w0.254: v12(37.92,77.14) 37.75,77.31 v8(37.51,77.31) ; v4(26.67,53.62) v1(27.11,53.62) 29.55,53.62 v8(30.51,52.66) ; v12(37.94,59.74) 37.86,59.66 v8(37.51,59.66) ; v4(29.99,63.55) 29.99,63.2 v1(29.89,63.1) 29.33,62.54 29.33,59.41 29.58,59.16 v8(30.01,59.16) ; v8(30.01,69.81) 29.99,69.79 29.99,66.47 v1(30.1,66.37) 29.99,66.27 v4(29.99,65.91) ; v8(37.51,69.81) 37.59,69.72 v12(37.92,69.72) ; v8(30.51,76.81) 29.42,75.72 v1(26.99,75.72) v4(26.54,75.72) ; v12(37.3,51.87) v8(37.01,52.16)
  BOTTOM w0.254: U23.A15 29.91,70.2 29.91,69.91 v8(30.01,69.81) ; U24.A16 v8(37.01,52.16) ; U24.T1 v8(30.01,59.16)
  BOTTOM w0.305: U23.R1 v8(37.51,77.31)
+V2.8_2M_F: length 4.9
  BOTTOM w0.305: R194.1 2.17,46 3.15,46 3.53,45.62 4.14,45.62 4.35,45.83 CN5.21
  BOTTOM w0.508: C136.1 2.74,44.9 C135.1 R194.1
+V3.3S_ACCEL: length 10.3
  BOTTOM w0.305: 167.41,75.46 166.65,75.46 166.39,75.72 166.39,78.51 166.75,78.88 U35.1 ; 170.71,75.46 U35.14
+V3.3S_GYRO: length 2.1
  BOTTOM w0.254: U32.16 96.46,39.23 ; U32.15 96.34,38.58
+V3.3S_SENSOR: length 52
  TOP w0.305: U10.9 98.43,42.3 98.98,42.85 99.2,42.85 C103.1 99.34,43.04 v5(99.79,43.5) ; R116.1 86.99,45.38 v9(86.99,44.91) ; R130.1 R133.1 ; R145.1 v5(97.81,46.85)
  IN1 w0.254: v9(90.31,37.7) 90.31,36.95 90.57,36.68 92.35,36.68 v5(93.54,35.49)
  IN2 w0.305: v5(94.26,46.86) v4(94.26,47.6) ; v4(97.84,47.6) 97.81,47.58 v5(97.81,46.85) v5(100.5,46.85) 100.5,46.36 99.36,45.21 v5(99.36,44.71) 99.36,43.77 99.63,43.5 v5(99.79,43.5) 100.44,43.5 100.5,43.56 103.58,43.56 103.78,43.36 v5(103.78,43.33) ; v5(93.54,35.49) 93.57,35.51 v5(94.23,35.51) 94.66,35.08 100,35.08 v5(100.2,35.28)
  IN3 w0.305: v4(97.84,47.6) 97.81,47.58 94.28,47.58 v4(94.26,47.6) 92.71,47.6 92.22,48.08 v1(91.11,48.08)
  IN4 w0.381: v1(92.86,40.12) 93.28,39.7 94.22,39.7 v1(94.64,40.12)
  BOTTOM w0.254: R343.2 v1(94.64,40.12)
  BOTTOM w0.305: v1(91.11,48.08) 91.11,45.8 90.32,45.01 v1(90.32,44.53) v1(90.32,44.1) v1(90.32,43.69) 91.03,42.98 91.03,40.54 91.28,40.29 90.57,39.57 90.57,37.96 v9(90.31,37.7)
  BOTTOM w0.381: R336.2 v1(92.86,40.12)
  BOTTOM w0.508: R336.2 91.63,40.12 91.46,40.29 91.28,40.29
+VBAT_R: length 26.9
  TOP w0.305: U10.24 91.89,45.32 91.59,45.62 C99.2 ; C101.2 98.45,36.91 98.01,37.34 U10.1 ; C101.2 C105.1 L1.1 ; C101.2 C100.2 97.56,36.7 97.39,36.87 U10.48 ; C98.2 91.26,36.32 U10.36
  IN2 w0.305: v5(91.89,44.43) 91.34,44.43 90.88,43.97 90.88,42.57 92.38,41.07 92.38,36.91 92.1,36.63 91.59,36.63 v5(91.21,36.25) 91.34,36.12 v5(97.56,36.12)
+VDDQ: length 42.7
  TOP w0.381: R22.1 C17.2
  TOP w0.508: C18.2 R23.1 41.04,49.56 40.43,48.95 v9(40.43,48.54) ; R22.1 41.02,74.64 v9(41.02,80.54)
  IN2 w0.305: v5(47.53,60.86) 47.53,61.06 47.29,61.3 v12(47.24,61.3)
  IN2 w0.381: v5(85.15,59.46) 85.15,58.97 v4(85.14,58.95)
  IN3 w0.254: v12(47.25,66.07) 47.29,66.07 v1(47.67,66.07) ; v1(85.28,59.4) 85.14,59.26 v4(85.14,58.95) ; v1(87.53,56.75) 87.68,56.75 87.96,57.02 87.96,57.86 86.62,59.2 86.29,59.2 85.99,59.5 85.99,59.88 86.08,59.97 86.08,60.73 v12(86.13,60.78) 86.08,60.83 v8(86.08,61.55)
  IN3 w0.305: v1(47.67,61.3) 47.29,61.3 47.29,61.3 v12(47.24,61.3)
  GND3 w0.254: v8(85.68,61.55) 85.68,61.18 86.08,60.78 v12(86.13,60.78)
  IN4 w0.102: 31.01,76.35 31.01,76.48 30.76,76.73 30.76,77.5 v1(31.01,77.75) 31.26,77.5 31.26,76.61 31.01,76.35 ; 31.01,76.35 v1(31.01,76.31) ; 37.89,70.05 37.26,70.05 v1(37.01,70.31) ; 30.76,51.97 30.76,52.91 v1(31.01,53.16) 31.26,52.9 31.26,51.97 v1(31.01,51.72) 30.76,51.97
  IN4 w0.127: 37.89,70.05 v1(38.33,70.05) ; v1(38.38,59.08) 38.38,59.16 38.12,59.41 37.41,59.41 37.16,59.16 v8(37.01,59.16)
  BOTTOM w0.254: v1(87.53,56.75) 87.53,53.87 87.73,53.67 87.73,49.05 87.93,48.85 88.13,48.85
  BOTTOM w0.305: v1(85.28,59.4) PU5.A10
  vias: v1(28.04,71.32) v1(28.04,70.94) v1(28.42,71.32) v1(28.42,70.97) v1(85.11,47.65) v1(85.11,47.32) v1(85.19,46.51) v1(85.52,47.65) v1(85.52,47.32) v1(85.7,46.48) v1(85.98,47.02) v1(85.98,46.66) v2(46.76,66.07) v2(84.91,56.52) v2(85.16,56.29) v3(46.76,66.07) v3(84.91,56.52) v3(85.16,56.29) v4(84.99,46.89) v4(85.52,46.89) v4(85.95,47.52) v5(46.76,66.07) v5(84.91,56.52) v5(85.16,56.29) v6(28.04,57.08) v6(28.06,57.48) v6(28.5,57.51) v6(28.5,57.08) v6(33,72.53) v6(33,72.18) v6(33,57.32) v6(33,56.96) v6(34.17,72.45) v6(34.17,72.15) v6(34.81,74.31) v6(34.78,56.3) v6(34.81,55.03) v6(35.11,56.28) v6(35.14,55.03) v6(35.16,74.31) v7(28.04,57.08) v7(28.06,57.48) v7(28.5,57.51) v7(28.5,57.08) v7(33,72.53) v7(33,72.18) v7(33,57.32) v7(33,56.96) v7(34.17,72.45) v7(34.17,72.15) v7(34.81,74.31) v7(34.78,56.3) v7(34.81,55.03) v7(35.11,56.28) v7(35.14,55.03) v7(35.16,74.31) v8(28.04,57.08) v8(28.06,57.48) v8(28.5,57.51) v8(28.5,57.08) v8(33,72.53) v8(33,72.18) v8(33,57.32) v8(33,56.96) v8(34.17,72.45) v8(34.17,72.15) v8(34.81,74.31) v8(34.78,56.3) v8(34.81,55.03) v8(35.11,56.28) v8(35.14,55.03) v8(35.16,74.31) v10(28.04,71.32) v10(28.04,70.94) v10(28.42,71.32) v10(28.42,70.97) v10(85.11,47.65) v10(85.11,47.32) v10(85.19,46.51) v10(85.52,47.65) v10(85.52,47.32) v10(85.7,46.48) v10(85.98,47.02) v10(85.98,46.66) v11(28.04,71.32) v11(28.04,70.94) v11(28.42,71.32) v11(28.42,70.97) v11(85.11,47.65) v11(85.11,47.32) v11(85.19,46.51) v11(85.52,47.65) v11(85.52,47.32) v11(85.7,46.48) v11(85.98,47.02) v11(85.98,46.66) v13(41.68,61.37) v14(48.82,50.27) v14(49.32,50.75) v14(49.91,50.34)
+VDDQ_VTT: length 7.8
  IN4 w0.254: v8(86.08,61.15) 86.08,61.01 86.53,60.56 86.53,59.74 86.92,59.36 86.92,58.78 87.53,58.17 89.18,58.17 v1(89.68,57.66)
  BOTTOM w0.254: R273.1 32.67,48.43 33.3,49.05 v13(33.3,49.79)
  vias: v1(89.68,57.2) v1(89.96,57.43) v1(90.24,57.66) v1(90.24,57.2) v1(90.45,55.48) v1(90.95,55.45) v1(91.49,55.45) v3(90.45,54.66) v3(90.78,54.66) v3(91.11,54.66) v4(90.67,55.09) v4(91.23,55.09) v5(90.45,54.66) v5(90.78,54.66) v5(91.11,54.66) v8(86.88,61.15) v9(25.19,76.79) v9(25.19,76.18) v9(25.32,49.1) v9(25.32,48.41) v10(90.45,55.48) v10(90.95,55.45) v10(91.49,55.45) v11(90.45,55.48) v11(90.95,55.45) v11(91.49,55.45)
AGND: length 3.3
  IN3 w0.254: 137.13,78.36 137.21,78.36 138.53,77.04 138.53,76.53 138.33,76.33 137.77,76.33
  vias: v1(115.54,78.44) v1(115.62,78.77) v1(116.06,80.39) v1(116.06,79.53) v1(116.79,79.83) v1(118.13,77.88) v1(118.13,64.94) v1(118.5,75.9) v1(119.02,64.94) v1(119.39,66.57) v1(119.78,78) v1(119.91,64.94) v1(120.04,81.43) v1(120.43,66.57) v1(120.55,79.15) v1(120.6,71.4) v1(120.8,81.43) v1(120.8,78.04) v1(120.8,64.94) v1(136.04,76.77) v1(137.02,76.86) v1(140.48,76.86) v1(140.61,76.23) v1(140.74,74.58) v1(140.81,76.86) v1(140.84,75.97) v2(122.73,77.37) v2(123.76,71.91) v2(123.76,71.02) v2(123.76,70.13) v2(123.76,69.24) v2(124.2,75.85) v3(123.76,71.91) v3(123.76,71.02) v3(123.76,70.13) v3(123.76,69.24) v4(123.36,80.75) v4(124.2,73.23) v4(124.43,69.06) v4(124.61,73.94) v5(123.76,71.91) v5(123.76,71.02) v5(123.76,70.13) v5(123.76,69.24) v10(137.02,76.86) v11(115.54,78.44) v11(115.62,78.77) v11(116.06,80.39) v11(116.06,79.53) v11(116.79,79.83) v11(117.03,78.39) v11(118.13,77.88) v11(118.13,64.94) v11(118.5,75.9) v11(119.02,64.94) v11(119.39,66.57) v11(119.78,78) v11(119.91,64.94) v11(120.04,81.43) v11(120.43,66.57) v11(120.55,79.15) v11(120.6,71.4) v11(120.8,81.43) v11(120.8,78.04) v11(120.8,64.94) v11(121.38,79.5) v11(121.38,79.05) v11(121.41,70.18) v11(121.48,71.17) v11(121.66,79.3) v11(121.82,78.03) v11(121.94,79.5) v11(121.94,79.07) v11(122.68,78.49) v11(123.85,78.46) v11(124.05,78.77) v11(136.04,76.77) v11(137.02,76.86) v11(140.48,76.86) v11(140.61,76.23) v11(140.74,74.58) v11(140.81,76.86) v11(140.84,75.97)
