# Allegro board da0ee6mbad0-d-susan-165XL-0828.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
XDP_H_TCK: length 12.3
  TOP w0.114: v5(54.62,75.5) 54.62,75.85 53.02,77.46 R40.2
  IN2 w0.064: v12(58.47,76.23) 58.26,76.02 55.14,76.02 54.62,75.51 v5(54.62,75.5)
  IN3 w0.06: 56.72,71.78 v8(56.72,71.56)
  IN3 w0.064: 56.72,71.78 56.72,72.44 58.04,73.76 58.04,74.16 57.98,74.21 57.98,75.45 58.11,75.58 58.11,75.87 v12(58.47,76.23)
XDP_H_TDI: length 15.7
  TOP w0.114: CN1.60 53.02,75.78 52.73,76.07 v5(52.73,76.1)
  IN2 w0.064: v12(58.47,74.68) 58.18,74.68 57.95,74.45 53.62,74.45 52.73,75.34 v5(52.73,76.1) 52.09,76.73 52.09,79.02 v5(52.22,79.15)
  IN3 w0.06: 57.27,71.78 57.27,71.17 57.05,70.95 v8(56.75,70.95)
  IN3 w0.064: v12(58.47,74.68) 58.34,74.55 58.34,73.64 57.27,72.57 57.27,71.78
XDP_H_TDO: length 17.7
  TOP w0.114: CN1.59 53.42,75.76 53.11,76.07 v5(53.11,76.1)
  IN2 w0.064: v5(53.11,79.15) 52.35,78.39 52.35,76.86 v5(53.11,76.1) 53.11,75.31 53.82,74.6 57.88,74.6 v12(58.47,75.19)
  IN3 w0.06: v8(56.75,69.82) 56.75,70.1 56.53,70.33 56.53,70.44 56.72,70.64 56.91,70.64 57.44,71.17 57.44,71.78
  IN3 w0.064: v12(58.47,75.19) 58.8,74.86 58.8,73.88 57.44,72.52 57.44,71.78
XDP_H_TMS: length 15.6
  TOP w0.114: v5(53.49,76.1) 53.49,76.07 53.82,75.74 CN1.58
  IN2 w0.064: v12(56.71,74.96) 56.51,74.75 54.25,74.75 53.49,75.52 v5(53.49,76.1) 52.6,76.99 52.6,78.39 53.11,78.89 53.74,78.89 v5(54,79.15)
  IN3 w0.06: 56.09,71.78 56.09,71.71 56,71.62 55.94,71.62 55.72,71.41 55.72,70.84 56.25,70.32 56.25,70 56.47,69.78 v8(56.47,69.54)
  IN3 w0.064: 56.09,71.78 56.09,72.38 55.93,72.54 55.93,73.23 55.98,73.28 55.98,74.02 56.71,74.75 v12(56.71,74.96)
XDP_H_TRST#: length 16.2
  TOP w0.114: v5(53.87,76.1) 54.22,75.75 CN1.57
  IN2 w0.064: v5(54.89,79.15) 54.38,78.64 53.24,78.64 52.85,78.26 52.85,77.12 v5(53.87,76.1) 53.87,75.41 54.15,75.13 56.43,75.13 56.58,75.28 56.85,75.28 57,75.13 57.32,75.13 v12(57.5,74.96)
  IN3 w0.06: v8(56.47,70.1) 56.37,70.2 56.37,70.49 56.26,70.6 56.26,70.74 56.42,70.9 56.42,71.12 56.46,71.16 56.46,71.53 56.24,71.75 56.24,71.78
  IN3 w0.064: v12(57.5,74.96) 57.5,74.25 57.73,74.02 57.73,73.89 56.24,72.4 56.24,71.78
XDP_PBI: length 4.3
  TOP w0.114: R88.1 65.57,77.01 64.92,77.01 64.67,76.76 63.6,76.76 62.62,75.79 CN1.36
XDP_RSMRST#: length 3.8
  TOP w0.114: CN1.37 62.22,75.69 63.52,76.99 64.54,76.99 64.93,77.38 R86.1
XDP_SLP_S0IX#: length 2
  TOP w0.114: CN1.45 59.02,76.13 58.51,76.65 58.51,77.24 R69.1
XDP_SLP_S3#: length 2.5
  TOP w0.114: R55.1 56.92,76.8 57.54,76.18 57.86,76.18 58.22,75.81 CN1.47
XDP_SLP_S4#: length 2.3
  TOP w0.114: CN1.46 58.62,76.24 58.29,76.57 58.29,76.94 57.92,77.31 R61.1
N05827: length 1.5
  BOTTOM w0.114: PU4.3 86.19,43.53 86.26,43.59 PR100.1
N128381: length 7.9
  IN4 w0.254: v8(86.88,61.95) 87.07,61.95 87.37,61.65 88.06,61.65 88.11,61.6
  IN4 w0.508: 92.07,61.22 91.46,60.61 89.1,60.61 88.11,61.6
  BOTTOM w0.114: v13(91.39,61.37) 91.47,61.28 PL18.2
  vias: v1(92.48,61.27) v1(92.83,61.27) v1(93.21,61.27) v1(93.54,61.27)
N128385: length 7.9
  IN4 w0.254: v8(86.88,61.55) 86.99,61.55 87.6,60.94 87.88,60.94
  IN4 w0.508: 87.88,60.94 88.9,59.92 92,59.92 92.12,59.79
  BOTTOM w0.114: PL18.1 v13(91.28,59.68)
  vias: v1(92.58,59.69) v1(92.94,59.69) v1(93.29,59.69) v1(93.65,59.69)
N210426: length 1.3
  IN4 w0.254: v1(86.08,60.35) 86.18,60.24 86.18,59.59 v1(86.56,59.21)
N513330: length 3.8
  IN4 w0.254: v8(86.88,63.15) 87.09,63.15 87.47,62.76 89.61,62.76 v1(89.84,62.99)
  BOTTOM w0.127: PU5.G15 v8(86.88,63.15)
N513406: length 4.9
  IN4 w0.254: v1(87.68,63.55) 88.74,63.55 89.61,64.42 91.87,64.42 v1(92.12,64.67)
N587789:
  vias: v1(87.6,72.92) v1(87.6,72.57) v1(88.03,72.95) v1(88.03,72.57) v1(88.44,72.92) v1(88.41,72.57) v8(85.28,65.55)
N10435301: length 13.9
  IN4 w0.06: v8(82.88,62.75) 82.68,62.95 82.68,63.24 82.58,63.35 81.84,63.35 81.73,63.24
  IN4 w0.254: 81.73,63.24 81.6,63.24 81.35,63.49 78.67,63.49 78.3,63.86 72.26,63.86 72.06,63.65 v1(70.72,63.65)
  BOTTOM w0.254: v1(70.72,63.65) PR68.1
N10438479: length 12.5
  IN4 w0.254: v1(70.72,64.54) 71.2,64.06 71.9,64.06 72.06,64.21 78.46,64.21 78.84,63.83 81.51,63.83 81.76,63.58
  BOTTOM w0.254: v1(70.72,64.54) PR67.1
  vias: v8(82.08,63.55)
N10505050: length 1.2
  GND3 w0.254: v8(86.48,64.35) 86.57,64.35 87.32,65.1 v12(87.4,65.1)
  vias: v2(87.19,65.51) v2(87.53,65.51) v3(87.19,65.51) v3(87.53,65.51) v5(87.19,65.51) v5(87.53,65.51)
N16680072: length 2
  TOP w0.114: D6.1 88.07,76.99 R120.2
N16686639: length 12
  TOP w0.508: F1.1 82.88,74.83 82.57,75.13 82.57,77.98 81.87,78.68 D4.1 C94.1 80.54,79.5 79.93,80.11 78.03,80.11 77.07,81.07 77.07,81.07 76.8,81.33
N16766415: length 1.2
  GND3 w0.254: v12(81.43,61.67) 81.56,61.8 82.11,61.8 82.26,61.95 v8(82.48,61.95)
  vias: v2(82.57,61.15) v3(82.57,61.15) v5(82.57,61.15)
N16778002: length 6.5
  IN2 w0.064: v4(90.07,64.21) 90.32,64.47 v5(90.62,64.47)
  IN3 w0.06: v8(84.88,63.15) 85.11,62.92 85.49,62.92 85.92,63.35 86.05,63.35 86.51,63.81 87.45,63.81
  IN3 w0.064: v4(90.07,64.21) 89.86,64.01 88.64,64.01 88.44,63.81 87.45,63.81
N16778585: length 3.1
  BOTTOM w0.114: 23.39,27.46 24.06,26.78 PR49.2 24.49,25.63 PQ6.4
N16783225: length 12
  IN4 w0.254: v1(79.79,46.76) 79.79,46.51 80.17,46.13 81.05,46.13 81.43,45.75 81.43,43.84 82.74,42.53 v1(82.74,40.41)
  BOTTOM w0.254: v1(82.74,40.41) 82.95,40.41 83.48,39.88 83.48,39.68 84.03,39.13 PU6.16
  BOTTOM w0.305: v1(79.79,46.76) 79.79,46.51 79.74,46.46 PQ10.4
N16783226: length 0.9
  BOTTOM w0.254: PR88.2 PR86.1
N16833323: length 1.1
  BOTTOM w0.381: PR61.2 66.91,67.29 PU3.5
N16833546: length 1.1
  BOTTOM w0.381: PR57.2 64.96,67.29 PU3.8
N16863834: length 2.3
  BOTTOM w0.508: PU4.5 82.25,45.43 82.23,45.41 C297.2 81.81,46.17 R329.1
N35983525: length 5.6
  TOP w0.114: v9(22.02,81.71) 22.07,81.71 22.75,82.4 SW2.5
  BOTTOM w0.114: v9(22.02,81.71) 22.02,82.11 T18.2 R226.1
N35984274: length 2.8
  TOP w0.114: R25.1 T2.2 45.4,82.4 SW3.5
N36538959: length 1.9
  BOTTOM w0.114: C338.1 120.2,76.61 119.91,76.61 119.7,76.39 U34.12
N36538961: length 1.6
  BOTTOM w0.114: C335.1 119.3,76.59 U34.11
N36539010: length 1.3
  BOTTOM w0.127: R372.2 116.48,76.61 116.5,76.59 U34.4
N36539066: length 4.1
  IN2 w0.064: v5(123.87,73.69) 123.87,73.48 v4(123.34,72.95)
  IN3 w0.064: v4(123.34,72.95) 123.06,73.23 121.92,73.23 121.29,72.6 v1(120.6,72.6)
N36539068: length 2.6
  IN2 w0.064: v4(122.45,73.59) 122.79,73.59 v5(122.89,73.69)
  IN3 w0.064: v4(122.45,73.59) 122.3,73.43 121.91,73.43 121.47,73 v1(120.6,73)
N36539082: length 2.8
  IN2 w0.064: v4(122.48,72.86) 122.54,72.8 v5(122.92,72.8)
  IN3 w0.064: v1(120.6,72.2) 121.1,72.2 121.93,73.03 122.31,73.03 v4(122.48,72.86)
N36539084: length 3.8
  IN2 w0.064: v4(121.99,72.59) 122.09,72.49 123.54,72.49 123.85,72.8 v5(123.9,72.8)
  IN3 w0.064: v1(120.6,71.8) 120.99,71.8 121.79,72.59 v4(121.99,72.59)
N37260993: length 1.9
  BOTTOM w0.114: CN7.7 36.05,9.04 35.96,9.13 35.96,9.64 R284.2
N37261001: length 1.9
  BOTTOM w0.114: CN7.9 35.55,9.09 35.76,9.3 35.76,9.72 R282.2
N37777638: length 4.5
  TOP w0.114: PR35.1 121.69,45.83 PR36.1 122.09,44.62 122.09,43.4 121.94,43.25 PR37.1 121.56,43.25 PR34.2
N37777761: length 8.5
  IN2 w0.203: v4(108.73,45.59) 108.73,45.54 109.17,45.11 111.2,45.11 113.38,47.3 114.14,47.3 114.58,46.86 v5(114.58,46.1)
  IN3 w0.203: v1(108.45,46.01) 108.45,45.87 v4(108.73,45.59)
N38078677: length 10
  BOTTOM w0.114: R202.1 C137.1 13.14,44.78 7.98,44.78 7.34,45.42 5.71,45.42 5.55,45.58 CN5.19
N38417315: length 4.2
  IN3 w0.064: v1(25.68,10.06) 25.68,9.51 25.8,9.39 v1(25.8,5.87)
N38417396: length 2
  BOTTOM w0.114: R274.2 32.79,9.77 32.05,9.03 CN7.23
N38556463: length 1.8
  BOTTOM w0.114: R253.2 27.45,9.51 27.55,9.42 CN7.41
N38556734: length 4.3
  IN3 w0.064: v1(26.3,5.87) 26.3,9.54 26.57,9.81 v1(26.57,10.06)
N38652260: length 1.9
  BOTTOM w0.114: CN7.25 31.55,9.42 31.9,9.77 R271.2
N39192357: length 6.9
  IN2 w0.064: v5(109.65,69.7) 110,70.05 v4(110,70.89)
  IN3 w0.064: v4(110,70.89) 110,71.05 110.79,71.83 112.83,71.83 v1(114.4,73.4)
N39319858: length 2.8
  BOTTOM w0.254: U22.E6 33.75,20.24 L7.2 34.82,20.05 C215.1
N40413592: length 10.4
  IN2 w0.064: v4(98.57,42.24) 99.56,43.23 102.41,43.23 v4(102.92,42.72)
  IN3 w0.064: v1(98.29,41.78) 98.29,42.01 98.52,42.24 v4(98.57,42.24) ; v1(102.92,42.27) v4(102.92,42.72)
  BOTTOM w0.114: R350.1 103.27,41.91 v1(102.92,42.27) ; R344.1 C303.1
  BOTTOM w0.127: C303.1 98.49,41.48 U32.1
N40413621: length 4.8
  BOTTOM w0.203: U31.7 94.13,41.35 C299.2 93.63,41.08 U31.8
  BOTTOM w0.305: C299.2 R338.2
N40413927: length 9.9
  IN3 w0.381: v1(15.14,32.25) 15.14,31.68 15.52,31.29 19.48,31.29 19.92,31.74 v1(19.92,35.97)
N40413993: length 1.4
  BOTTOM w0.114: R206.1 17.88,33.13 U19.8
N40414179: length 4.3
  IN2 w0.064: v5(8.13,43.75) 8.45,43.75 v4(8.63,43.56)
  IN3 w0.064: v1(9.09,43.74) 8.91,43.56 v4(8.63,43.56)
  BOTTOM w0.114: v1(9.09,43.74) 9.27,43.92 11.66,43.92 11.79,43.78 R9.1
N40571483: length 2.7
  TOP w0.114: C115.1 114.6,62.7 U12.J8
N40575480: length 2.6
  TOP w0.114: U12.J6 115.9,62.14 115.9,62.79 115.08,63.6 R173.2
N41116181: length 1.4
  TOP w0.114: R390.2 161.61,82.26 v9(161.59,82.27)
  BOTTOM w0.114: U36.B10 162.06,81.8 v9(161.59,82.27)
N41116184: length 2.2
  TOP w0.114: TP38.1 161.19,80.77 v9(160.8,80.39)
  BOTTOM w0.114: v9(160.8,80.39) 161.59,80.39 U36.D10
N41119598: length 2.7
  TOP w0.114: TP37.1 155.98,80.65 v9(157.12,79.5)
  BOTTOM w0.114: U36.E4 156.99,79.35 156.99,79.38 v9(157.12,79.5)
N41119599: length 1.4
  TOP w0.114: TP34.1 156.16,79.38 v9(156.28,79.5)
  BOTTOM w0.114: U36.E3 155.8,79.02 v9(156.28,79.5)
N41122329: length 1.6
  TOP w0.114: TP40.1 155.09,74.68 v9(155.34,74.93)
  BOTTOM w0.114: v9(155.34,74.93) 154.86,75.41 U36.J2
N41122637: length 1.5
  TOP w0.114: TP41.1 155.98,76.96 v9(156.23,76.71)
  BOTTOM w0.114: v9(156.23,76.71) 156.15,76.71 U36.H3
N41123562: length 2.8
  TOP w0.114: v9(158.01,77.73) 158.01,77.98 158.65,78.61 TP39.1
  BOTTOM w0.114: v9(158.01,77.73) 158.52,77.73 159.03,77.22 U36.G7
N41296642: length 4.2
  TOP w0.508: R196.2 7.71,64.76 7.92,64.54 7.92,63.37 7.69,63.15 6.52,63.15 6.32,62.94 LED3.2
N41296646: length 6.7
  TOP w0.508: Q12.3 8.62,66.76 8.99,66.4 8.99,62.82 8.53,62.36 LED3.1
N41297294: length 1.3
  BOTTOM w0.508: LED2.2 6.88,73.53 R195.2
N41297298: length 2.3
  BOTTOM w0.508: Q13.3 8.45,75.1 LED2.1
N41360512: length 6.4
  BOTTOM w0.114: R311.1 18.79,57.19 18.79,57.88 C151.2 18.31,58.83 18.85,59.37 CN6.14
N41625256: length 6.6
  IN4 w0.06: v8(50.53,70.95) 50.16,71.32 50.16,71.88 51.08,72.8 51.08,73.97
  IN4 w0.064: 50.75,75.14 50.75,74.3 51.08,73.97
  IN4 w0.127: 50.75,75.14 50.21,75.67 v1(50.21,76.7)
N41632616: length 10.7
  IN3 w0.06: 50.43,71.78 50.43,69.92 v8(50.53,69.82)
  IN3 w0.064: 50.43,71.78 50.43,72.49 50.52,72.58 51.01,73.08 51.01,74.17 50.67,74.51 50.67,75.62 50.17,76.12 50.17,77.03 49.73,77.47 49.73,79.58 v1(49.81,79.66)
N41632617: length 15.6
  IN3 w0.06: 50.28,71.78 50.28,69.57 v8(50.25,69.54)
  IN3 w0.064: 50.28,71.78 50.28,72.58 50.86,73.17 50.86,74.11 50.52,74.45 50.52,75.56 50.02,76.06 50.02,76.96 49.58,77.4 49.58,79.43 v1(48.46,80.54)
  BOTTOM w0.114: v1(48.46,80.54) 48.46,80.39 47.42,79.35 47.42,78.46 TP53.1
N41632618: length 10.2
  IN3 w0.06: 50.58,71.78 50.58,70.36 50.81,70.13 v8(50.81,69.54)
  IN3 w0.064: 50.58,71.78 50.58,72.43 51.16,73.01 51.16,74.16 51.46,74.45 51.46,75.6 50.37,76.69 50.37,77.06 49.93,77.5 49.93,78.54 v1(49.98,78.59)
N41660457: length 1.3
  TOP w0.114: v9(158.01,80.39) 158.04,80.42 TP35.1
  BOTTOM w0.114: v9(158.01,80.39) 158.46,79.94 U36.D6
N41660819: length 4.9
  TOP w0.114: v9(158.03,79.5) 157.8,79.5 157.29,79 156.53,79 R400.1
  BOTTOM w0.114: U36.E6 158.46,79.1 158.06,79.5 v9(158.03,79.5)
N41680923: length 8.2
  BOTTOM w0.305: CN11.6 122.17,58.31 122.17,58.32
  BOTTOM w0.508: 122.17,58.32 122.38,58.53 122.38,60.98 122.02,61.34 120.47,61.34 119.59,60.47 C330.2 R373.1
N41686100: length 1.8
  TOP w0.114: v9(158.01,81.15) 158.14,81.28 TP31.1
  BOTTOM w0.114: v9(158.01,81.15) 158.46,81.6 U36.B6
N41686129: length 1.3
  TOP w0.114: TP33.1 v9(159.79,81.28)
  BOTTOM w0.114: v9(159.79,81.28) 159.36,80.85 U36.C7
N41686569: length 1.3
  TOP w0.114: TP32.1 159.84,80.39 v9(159.81,80.39)
  BOTTOM w0.114: U36.D7 159.36,79.94 v9(159.81,80.39)
N41686570: length 1.7
  TOP w0.114: TP36.1 156.99,80.52 v9(157.12,80.39)
  BOTTOM w0.114: v9(157.12,80.39) 157.56,79.95 U36.D5
N41737727: length 12.6
  IN4 w0.06: v8(82.08,62.35) 81.72,62.35
  IN4 w0.127: 81.72,62.35 81.1,62.97 75.84,62.97 75.72,62.85 70.8,62.85 v1(70.72,62.76)
  BOTTOM w0.127: v1(70.72,62.76) PR69.2
N41742707: length 7.7
  IN2 w0.203: v4(109.29,45.59) 109.47,45.42 111.07,45.42 113.27,47.61 114.21,47.61 114.58,47.98 v5(114.58,48.72)
  IN3 w0.203: v1(109.55,46.01) 109.55,45.85 v4(109.29,45.59)
N41769021: length 1.5
  BOTTOM w0.114: R331.1 86.38,45.62 86.19,45.43 PU4.1
N41804483: length 2.2
  TOP w0.114: C116.2 114.01,69.73 J1.6
N41829139: length 12.1
  IN4 w0.254: v1(82.74,39.52) 82.32,39.94 82.32,42.32 81.05,43.59 81.05,45.49 80.79,45.75 79.65,45.75 79.02,46.38 79.02,46.5 79.01,46.51 v1(79.01,46.76)
  BOTTOM w0.254: PU6.15 82.74,38.63 PC73.2 v1(82.74,39.52)
N41829157: length 1.6
  BOTTOM w0.254: PU6.3 86.25,41.13 PR99.1
N41829227: length 1.8
  BOTTOM w0.254: PC86.2 86.75,40.74 PU6.4
N41829291: length 2.3
  BOTTOM w0.254: PU6.12 85.25,35.79 PR91.2 PR87.1
N41833804: length 4.2
  IN2 w0.064: v5(89.28,65.43) 88.8,65.43 v4(88.72,65.36)
  IN3 w0.06: 87.45,64.77 86.76,64.77 86.03,64.03 85.9,64.03 85.81,63.95 v8(85.68,63.95)
  IN3 w0.064: v4(88.72,65.36) 88.34,65.36 87.75,64.77 87.45,64.77
N41833869: length 6.2
  IN2 w0.064: v5(88.87,68.25) 88.87,68.15 v4(89.13,67.9)
  IN3 w0.06: v8(85.68,64.35) 86.11,64.35 87.19,65.43 87.19,66.14
  IN3 w0.064: v4(89.13,67.9) 89,67.77 88.11,67.77 87.19,66.85 87.19,66.14
N41834210: length 6.6
  IN2 w0.064: v4(81.91,58.65) 81.91,58.52 81.3,57.91 v5(81.3,56.92)
  IN3 w0.06: v8(84.08,62.35) 84.08,62.31 82.7,60.94 82.7,60.22 81.91,59.44 81.91,59.11
  IN3 w0.064: v4(81.91,58.65) 81.91,59.11
N41858843: length 1.7
  TOP w0.114: U10.45 95.89,37.05 96.42,36.53 TP13.1
N41989961: length 1.6
  BOTTOM w0.254: PC80.1 85.75,41.26 PU6.2
N42014000: length 6.8
  IN3 w0.064: v1(153.54,80.9) 152.96,81.48 149.32,81.48 v1(148.99,81.15)
  BOTTOM w0.114: U36.D2 154.86,79.99 154.45,80.39 153.87,80.39 153.54,80.72 v1(153.54,80.9)
N42025284: length 5.1
  TOP w0.254: R188.2 PR43.2 161.57,73.53 161.37,73.73 U13.4
N42027821: length 6.7
  IN4 w0.06: v8(50.81,70.67) 50.81,70.95 50.31,71.45 50.31,71.76 51.2,72.65 51.2,75.13
  IN4 w0.127: v1(51.08,76.7) 51.08,75.26 51.2,75.13
N42057036: length 1.8
  TOP w0.254: D2.2 62.49,47.7 R84.1
N42057039: length 9.9
  TOP w0.254: D1.2 60.65,48.9 66.14,48.9 66.89,49.64 67.45,49.64 67.88,49.21 R91.1
N42089549: length 3.2
  BOTTOM w0.305: R222.1 20.84,63.57 19.75,64.65 CN6.10
N42090986: length 5
  IN2 w0.064: v4(79.3,62.05) 79.18,61.94 v5(79.18,61.62)
  IN3 w0.064: v11(79.75,62) 79.35,62 v4(79.3,62.05)
  IN4 w0.06: 81.51,62.16 81.51,62.15 83.48,62.15 v8(83.68,62.35)
  IN4 w0.07: 81.35,62.08 81.43,62.16 81.51,62.16
  IN4 w0.127: v11(79.75,62) 81.28,62 81.35,62.08
N42091018: length 27.9
  IN2 w0.064: v4(79.91,50.98) 81.61,50.98 83.36,49.23 83.36,46.53 v4(83.33,46.51)
  IN3 w0.064: v1(83.84,46.51) v4(83.33,46.51) ; v11(80.84,56.77) 80.64,56.77 79.78,55.91 79.78,54.64 80.16,54.26 80.16,51.23 v4(79.91,50.98)
  IN4 w0.06: 81.35,59.62 81.78,60.05 81.78,60.78 82.04,61.04 82.49,61.04 82.79,61.35 82.98,61.35 83.19,61.56 83.4,61.56 83.99,62.15 84.16,62.15 84.16,62.14 84.27,62.26 84.28,62.26 84.28,62.63 83.97,62.95 83.48,62.95 v8(83.28,62.75)
  IN4 w0.127: v11(80.84,56.77) 80.9,56.82 80.9,59.16 81.35,59.62
  BOTTOM w0.114: PR94.1 84.44,42.23 84.24,42.43 84.24,46.12 v1(83.84,46.51)
N42160594: length 5.1
  BOTTOM w0.203: 116.4,58.35 116.51,58.45 U33.7 ; U33.8 116.42,57.95 116.4,57.94
  BOTTOM w0.381: 116.4,58.35 116.4,57.18 116.57,57.01 C324.2 116.47,57.02 115.48,57.02 R364.2
N42185424: length 3.5
  TOP w0.114: U2.2 15.69,83.64 v9(16.61,83.64)
  BOTTOM w0.114: v9(16.61,83.64) 16.61,81.74 16.83,81.52 R212.2
N42223725: length 7.1
  IN3 w0.064: v1(120.6,73.8) 120.96,73.43 121.47,73.43 122.26,74.21 123.14,74.21 124.87,75.95 125.7,75.95 125.83,76.07 v1(125.88,76.07)
  BOTTOM w0.114: TP62.1 v1(125.88,76.07)
N42223726: length 7
  IN3 w0.064: v1(125.88,75.72) 125.8,75.8 124.96,75.8 123.23,74.06 122.32,74.06 121.54,73.28 120.71,73.28 v1(120.6,73.4)
  BOTTOM w0.114: TP63.1 v1(125.88,75.72)
N42223764: length 3.9
  TOP w0.114: v5(116.53,70.51) 116.79,70.26 R174.1
  IN2 w0.064: v5(116.53,70.51) 116.51,70.54 v4(116.51,70.94)
  IN3 w0.064: v1(114.32,71.78) 115.08,71.78 115.92,70.94 v4(116.51,70.94)
N42223850: length 2.2
  BOTTOM w0.305: PR66.1 67.17,56.96 66.28,57.84 PQ8.4
N42255362: length 3.6
  BOTTOM w0.114: PQ7.4 58.66,51.17 58.51,51.02 58.51,50.73 PR53.1
N42265286: length 3
  IN3 w0.064: v1(11.45,65.18) 11.96,65.18 12.21,65.43 14.25,65.43 v1(14.35,65.34)
N42265781: length 8.4
  IN3 w0.254: v1(17.42,10.82) 18.22,11.62 18.22,14.59 17.12,15.7 15.02,15.7 v1(14.59,15.27)
N42265817: length 1.3
  BOTTOM w0.114: U20.8 17.38,12.81 R225.1
N42277903: length 3.3
  BOTTOM w0.114: PAD1.1 11.94,40.83 R210.1
N42282408: length 6.4
  TOP w0.114: v5(118.64,62.56) 119.3,63.22 R179.2 ; U12.J7 115.1,61.94 v5(115.47,62.31)
  IN2 w0.064: v5(115.47,62.31) 115.34,62.43 115.34,62.76 115.49,62.92 116.1,62.92 116.3,62.71 118.49,62.71 v5(118.64,62.56)
N42282522: length 5.4
  TOP w0.114: v5(118.67,62.16) 118.77,62.26 R180.2
  IN2 w0.064: v5(118.67,62.16) 118.28,62.54 116.18,62.54 116.1,62.46 v5(116.1,61.34)
N42286068: length 7.9
  TOP w0.114: R172.1 114.33,64.84 114.63,64.54 114.63,63.12 115.08,62.66 v5(115.59,62.66) ; v5(116.99,59.34) 117.59,59.34 U12.D2
  IN2 w0.064: v5(116.99,59.34) 116.99,59.49 116.61,59.87 116.61,60.89 116.43,61.06 116,61.06 115.85,61.22 115.85,62.41 v5(115.59,62.66)
N42332245: length 8.8
  TOP w0.114: TP27.1 124.58,59.8 124.58,60.03 124.34,60.28 v2(124.3,60.28)
  IN1 w0.064: v2(124.3,60.28) 124.2,60.28 123.96,60.03 123.29,60.03 122.96,60.36 120.7,60.36 120.56,60.5 117.91,60.5 117.6,60.19 v2(117.6,59.84)
N42332246: length 9.4
  TOP w0.114: U12.F2 117.61,60.34 v2(117.86,60.1) ; v2(124.3,59.92) 124.3,59.21 125.04,58.47 TP29.1
  IN1 w0.064: v2(117.86,60.1) 117.86,60.23 117.98,60.35 120.49,60.35 120.64,60.21 122.9,60.21 123.23,59.88 124.26,59.88 v2(124.3,59.92)
N42340730: length 3.2
  TOP w0.203: U11.9 97.43,74.7 97.56,74.58 97.56,73.69 97.81,73.43 C102.1
  TOP w0.381: R151.1 C102.1
N42340810: length 2.2
  TOP w0.114: R150.1 R149.1 98.05,75.1 U11.10
N42352593: length 1.2
  BOTTOM w0.114: Y2.1 36.18,24.06 36.38,24.26 TP44.1
N42360901:
  vias: v9(56.13,37.47)
N42365464: length 5.4
  BOTTOM w0.114: TP56.1 57.55,40.59 57.55,40.03 57.81,39.78 57.81,36.98 57.35,36.53 CN9.1
N42370028: length 3.7
  BOTTOM w0.114: R205.1 14.5,4.09 14.12,3.71 PAD2.1
N42406876: length 2
  TOP w0.114: R6.2 5.39,72.48 LED1.2
N42406878: length 2.5
  TOP w0.114: LED1.3 3.57,71.15 R4.2
N42457191: length 7
  BOTTOM w0.114: TP42.1 17.8,56.16 17.8,60.16 18.25,60.61 CN6.15
N42457592: length 30.1
  IN3 w0.064: v1(16.93,44.99) 16.93,46.35 17.8,47.22 17.8,48.79 16.96,49.63 14.2,49.63 12.95,50.88 12.95,62.41 12.82,62.54 9.85,62.54 9.6,62.79 9.6,65.15 v1(9.9,65.46)
  BOTTOM w0.114: R207.2 10.18,65.18 v1(9.9,65.46) ; R215.2 17.04,44.44 16.93,44.55 v1(16.93,44.99)
N42478813: length 5.3
  TOP w0.305: PQ4.4 148.27,72.92 148.06,73.13 PR39.2 147.72,73.09 147.72,72.34 147.16,71.78 PQ3.3
N42479557: length 4.3
  BOTTOM w0.114: 16.28,43.64 16.13,43.79 15.74,43.79 15.63,43.67 Q14.3 ; 16.28,43.64 Q14.2 ; 16.28,43.64 16.51,43.87 17.56,43.87 R216.2
N42488414: length 1.3
  TOP w0.076: R131.1 94.68,74.52 94.96,74.52 95.15,74.7 U11.4
N42488420: length 1.3
  TOP w0.076: U11.5 95.15,74.3 95.08,74.37 94.8,74.37 R132.1
N42879454: length 4.6
  TOP w0.114: R404.2 C376.2 111.66,50.95 111.79,50.81 U37.8 111.79,49.27 111.96,49.1 112.14,49.1 112.29,49.26 U37.7
N43004274: length 1.9
  TOP w0.114: D5.1 88.73,80.8 88.43,80.51 R118.2
N43015076: length 4.2
  IN2 w0.064: v5(78.45,64.8) 78.86,64.8 v4(78.91,64.85)
  IN3 w0.064: v4(78.91,64.85) 78.91,64.57 v11(79.07,64.42)
  IN4 w0.06: v8(82.08,63.95) 81.95,63.95 81.56,64.34 81.35,64.34
  IN4 w0.127: v11(79.07,64.42) 79.14,64.34 81.35,64.34
N43058832: length 2.7
  TOP w0.114: R411.1 112.46,59.84 U12.E9
N43095716: length 4.4
  TOP w0.114: Q22.2 50.82,42.06 50.7,41.94 R664.2 50.15,40.83 49.74,41.24 Q23.3
N43426773: length 4.9
  TOP w0.114: R672.1 84.87,43.41 85.21,43.41 85.47,43.16 85.47,42.44 85.34,42.32 Q24.2 84.02,42.32 83.84,42.14 83.84,41.81 83.98,41.67 Q24.3
N66087087: length 1.4
  TOP w0.114: CN1.19 60.22,73.18 60.87,72.53 R75.2
N66113513: length 3.4
  IN2 w0.305: v4(88.74,66.14) 88.95,66.14 v5(89.25,66.45)
  IN3 w0.127: v11(88.52,65.76) 88.57,65.81 88.57,65.97 v4(88.74,66.14)
  IN4 w0.06: v8(86.88,65.55) 87.03,65.7 87.03,66.03 87.17,66.17 87.45,66.17
  IN4 w0.127: 87.45,66.17 88.24,66.17 88.52,65.89 v11(88.52,65.76)
N66113522: length 4.7
  TOP w0.114: PR19.1 PR16.2 89.06,57.98 v5(88.54,58.5)
  IN2 w0.064: v4(88.19,58.85) v5(88.54,58.5)
  IN3 w0.064: v4(88.19,58.85) 87.98,59.06 87.98,59.69 v1(87.86,59.82)
  BOTTOM w0.114: PU5.A14 86.88,60.24 87.3,59.82 v1(87.86,59.82)
N66925537: length 1.7
  BOTTOM w0.254: PR77.1 71.1,50.7 70.31,51.49 PQ9.4
N67532838: length 1.8
  IN2 w0.305: v5(81.73,61.16) 81.58,61.16 v12(81.38,60.96)
  GND3 w0.254: v12(81.38,60.96) 81.78,61.37 82.3,61.37 v8(82.48,61.55)
N67533172: length 1.2
  IN2 w0.305: v12(81.76,64.95) 81.84,64.87 v5(82.17,64.87)
  GND3 w0.254: v12(81.76,64.95) 81.96,64.75 v8(82.48,64.75)
N3723389213: length 1.5
  TOP w0.114: v5(32.31,21.64) 32.66,21.29 TP1.1
  IN2 w0.064: v4(32.2,21.21) 32.2,21.54 v5(32.31,21.64)
  IN3 w0.064: v4(32.2,21.21) 32.03,21.04 v1(31.79,21.04)

## Copper pours and planes (outline as drawn)
+1.8V_EMMC on TOP (solid shape): 32.98,31.54 33.31,31.54 33.85,30.99 33.85,30.48 33.7,30.33 31.16,30.33 31.01,30.48 31.01,31.42 31.14,31.55 32.97,31.55
+1.8V_EMMC on BOTTOM (solid shape): outline of 267 points within 28.14,29.44 38,36.78
+1V on TOP (solid shape): 64,68.18 64,67.74 63.98,67.72 61.39,67.72 61.39,68.23 63.95,68.23
+1V on BOTTOM (solid shape): 67.71,59.21 67.71,58.45 67.59,58.32 66.24,58.32 66.09,58.47 65.38,58.47 65.3,58.4 65.3,57.43 63.65,57.43 63.6,57.48 63.6,59.29 63.7,59.39 66.27,59.39 66.34,59.46 67.46,59.46
+1V on IN1 (solid shape): outline of 221 points within 51.99,57.43 68.91,79.38
+1V05 on BOTTOM (solid shape): 89.47,77.46 89.51,77.46 89.52,77.47 90.85,77.47 90.95,77.37 90.95,74.02 90.94,73.98 90.9,73.97 87.09,73.97 86.94,74.12 86.94,75.69 87.19,75.95 88.03,75.95 88.04,75.94 88.16,75.9 88.29,75.91 88.31,75.92 88.32,75.93 88.55,76.19 88.43,76.51 88.42,76.53 88.41,76.55 88.41,78.03 88.49,78.11 88.82,78.11
+1V05 on IN1 (solid shape): 54.7,80.34 54.89,80.24 55.08,80.34 57.58,80.34 57.65,80.31 57.68,80.25 57.91,80.04 58.14,80.25 58.17,80.31 58.24,80.34 67.54,80.34 67.62,80.3 67.64,80.22 67.87,79.93 68.09,80.22 68.11,80.3 68.19,80.34 69.92,80.34 70.43,79.83 70.43,79.76 70.58,79.61 70.58,78.98 70.63,78.93 70.63,78.55 70.6,78.48 70.58,77.23 70.35,77 70.35,76.75 70.58,76.52 70.58,76.01 70.63,75.96 70.63,74.02 70.86,73.79 70.86,73.78 70.89,73.7 70.94,73.64 71.05,73.53 81.2,73.53 84.02,76.35 86.69,76.35 88.46,78.13 88.82,78.13 89.07,77.88 89.07,77.67 86.99,75.59 84.2,75.59 81.53,72.92 70.94,72.92 70.1,73.76 70.1,76.15 69.82,76.43 69.82,77.7 70.1,77.98 70.1,78.82 69.47,79.45 62.54,79.45 62.5,79.49 55.5,79.49 55.46,79.45 52.32,79.45 52.24,79.38 52.22,79.38 52.05,79.31 51.99,79.13 51.99,79.13 51.99,77.62 50.72,76.35 49.12,76.35 49.02,76.46 49.02,76.96 49.4,77.34 50.19,77.34 50.72,77.88 50.72,79.45 51.23,79.96 51.25,79.96 51.51,80.05 51.63,80.29 51.64,80.34
+1V05_SOC on BOTTOM (solid shape): 49.55,56.21 49.55,55.86 49.23,55.54 49.23,54.19 49.17,54.13 48.79,54.13 48.74,54.18 48.74,55.63 49.22,56.11 49.22,56.19 49.35,56.31 49.45,56.31
+1V05_SOC on BOTTOM (solid shape): 51.33,74.98 51.33,74.27 51.19,74.13 51.19,72.91 51.84,72.26 51.84,72.16 51.69,72.01 51.58,72.01 51.57,72.02 51.37,72.09 51.18,72.01 51.05,72.01 51.03,72.02 51.01,72.03 50.75,72.12 50.56,71.92 50.56,71.9 50.39,71.73 50.35,71.7 50.32,71.66 50.29,71.63 50.21,71.63 50.18,71.64 50.15,71.69 50.11,71.73 50.09,71.74 50.09,71.77 50.09,71.88 50.11,71.91 50.17,71.96 50.21,72.01 50.26,72.06 50.26,73.08 50.19,73.15 50.19,74.07 49.8,74.46 49.8,75.01 49.82,75.03 51.28,75.03
+1V05_SOC on IN1 (solid shape): outline of 177 points within 45.79,54.15 51.38,75.31
+1V05_SOC on IN3 (solid shape): 49.6,67.16 49.6,66.9 49.98,66.52 49.98,64.97 49.58,64.57 49.58,64.03 49.5,63.96 48.76,63.96 48.59,64.14 48.59,67.01 48.79,67.21 49.55,67.21
+1V8 on TOP (solid shape): 91.59,59.36 91.59,56.14 91.49,56.03 90.93,56.03 90.83,56.14 90.83,59.31 90.93,59.41 91.54,59.41
+1V8 on TOP (solid shape): 55.47,54.84 55.47,50.93 55.37,50.83 54.43,50.83 54.3,50.95 54.3,54.15 54.51,54.36 54.51,54.94 55.37,54.94
+1V8 on TOP (solid shape): 58.01,42.57 58.01,42.06 57.93,41.99 56.92,41.99 56.79,41.86 56.79,39.52 56.77,39.5 56.05,39.5 56.03,39.52 56.03,42.42 56.28,42.67 57.91,42.67
+1V8 on TOP (solid shape): 86.2,54.59 86.64,54.15 86.64,53.32 86.71,53.24 86.71,50.83 86.56,50.67 85.54,50.67 85.49,50.73 85.49,53.62 85.7,53.82 85.7,55.14 86.2,55.14
+1V8 on TOP (solid shape): 112.39,47.4 112.39,46 111.99,45.59 111.5,45.59 111.32,45.42 111.32,43.99 111.48,43.84 112.16,43.84 112.24,43.92 112.24,44.38 112.39,44.53 113,44.53 113.1,44.43 113.1,43.64 112.93,43.46 110.79,43.46 110.72,43.54 110.72,45.44 111.27,46 111.96,46 112.21,46.25 112.21,47.4 112.24,47.42 112.37,47.42
+1V8 on BOTTOM (solid shape): 34.29,32.01 34.29,29.54 34.21,29.47 33.45,29.47 33.45,31.98 33.6,32.13 34.16,32.13
+1V8 on BOTTOM (solid shape): 111.91,82.2 111.91,80.49 111.82,80.41 111.82,79.82 111.78,79.78 111.53,79.78 111.4,79.91 111.4,81.31 111.27,81.43 111.27,82.2 111.4,82.32 111.78,82.32
+1V8 on BOTTOM (solid shape): 93.88,47.75 93.88,47.25 94.23,46.89 94.23,45.32 94.04,45.32 94.04,46.58 93.93,46.69 93.32,46.69 93.19,46.56 93.19,45.59 91.82,44.22 91.82,43.87 91.77,43.82 91.36,43.82 91.31,43.87 91.31,44.55 92.33,45.57 92.33,47.86 92.35,47.88 93.75,47.88
+1V8 on IN1 (solid shape): 163.85,82.83 163.85,77.22 162.42,75.78 157.95,75.78 157.58,75.41 157.58,74.25 156.38,73.05 153.06,73.05 152.68,72.67 152.68,71.35 149.36,68.04 130.26,68.04 128.32,66.09 128.32,64.49 128.27,64.44 127.91,64.44 127.85,64.5 127.85,66.38 130.01,68.54 148.4,68.54 148.44,68.58 149.02,68.58 151.84,71.4 151.91,71.4 152.04,71.53 152.04,73.31 152.42,73.69 155.95,73.69 156.85,74.59 156.85,75.83 157.5,76.48 161.92,76.48 163.09,77.65 163.09,82.2 163.01,82.27 162.51,82.27 162.33,82.45 162.33,82.96 162.46,83.08 163.6,83.08
+1V8 on IN1 (solid shape): outline of 174 points within 76.65,58.9 91.44,63.53
+1V8 on IN1 (solid shape): outline of 1530 points within 15.72,14.28 122.83,82.48
+1V8 on IN2 (solid shape): 112.16,82.07 112.16,81.43 111.91,81.18 104.04,81.18 103.65,81.56 103.65,81.81 104.04,82.2 112.04,82.2
+1V8_SOC on TOP (solid shape): 48.74,68.61 48.74,65.33 47.98,64.57 47.98,62.71 48.89,61.8 48.89,60.3 49.07,60.12 50.09,60.12 50.19,60.02 50.19,59.62 50.14,59.56 49.02,59.56 48.92,59.46 48.92,55.98 49.93,54.97 53.49,54.97 53.57,55.04 53.57,56.08 53.64,56.16 54.1,56.16 54.17,56.08 54.17,54.41 53.97,54.21 52.24,54.21 52.14,54.1 52.14,53.06 52.04,52.96 51.71,52.96 51.63,53.04 51.63,54.18 51.51,54.31 49.68,54.31 48.31,55.68 48.31,61.37 47.44,62.23 47.44,64.82 48.23,65.61 48.23,68.61 48.26,68.63 48.71,68.63
+1V8_SOC on BOTTOM (solid shape): 51.45,56.67 51.48,56.62 51.53,56.59 51.53,56.47 51.38,56.31 51.38,55.96 51.51,55.83 51.51,53.6 51.48,53.57 51,53.57 50.97,53.6 50.97,55.68 50.93,55.73 50.93,56.22 51.03,56.32 51.06,56.47 51.07,56.5 51.11,56.52 51.21,56.57 51.29,56.66 51.3,56.69 51.43,56.69
+1V8_SOC on BOTTOM (solid shape): 53.7,56.69 53.76,56.62 53.84,56.57 53.85,56.56 53.95,56.46 53.96,56.4 53.97,56.32 54.1,56.2 54.1,56.19 54.15,56.14 54.15,54.71 54.28,54.59 54.28,54.21 53.77,54.21 53.72,54.26 53.72,54.94 53.64,55.02 53.64,56.1 53.65,56.16 53.64,56.29 53.59,56.34 53.56,56.37 53.54,56.39 53.46,56.47 53.46,56.57 53.49,56.59 53.54,56.63 53.58,56.69 53.6,56.72 53.68,56.72
+1V8S5 on TOP (solid shape): 99.87,76 99.87,74.91 100.07,74.7 100.4,74.7 100.4,74.22 100.38,74.19 99.87,74.19 99.36,74.7 99.36,75.74 99.23,75.87 99.23,76.18 99.31,76.25 99.62,76.25
+1V8S5 on TOP (solid shape): 84.43,54.56 84.83,54.15 84.83,52.68 84.86,52.68 84.88,52.66 84.88,51.67 84.78,51.56 84.15,51.56 83.87,51.28 83.87,50.37 83.79,50.29 82.37,50.29 82.32,50.34 82.32,52.33 82.47,52.48 82.83,52.48 83.92,53.57 83.92,55.12 83.94,55.14 84.43,55.14
+1V8S5 on TOP (solid shape): 39.75,50.52 39.75,47.73 39.98,47.5 46.55,47.5 47.7,46.36 57.86,46.36 58.06,46.15 58.06,43.51 57.83,43.28 47.88,43.28 46.66,42.06 45.84,42.06 43.14,44.77 37.37,44.77 29.51,36.91 29.51,16.18 31.8,13.9 39.85,13.9 40.33,13.41 40.33,11.71 39.8,11.71 39.8,12.88 39.47,13.21 29.64,13.21 29,13.84 29,15.14 28.65,15.5 28.65,37.64 37.26,46.25 37.26,50.27 37.64,50.65 39.62,50.65
+1V8S5 on BOTTOM (solid shape): 87.27,54.99 87.27,53.72 87.51,53.48 87.51,48.96 87.53,48.95 87.53,48.77 87.4,48.64 85.19,48.64 85.06,48.77 85.06,49.61 85.26,49.81 86.05,49.81 86.26,50.01 86.26,53.6 86.05,53.8 85.01,53.8 84.88,53.93 84.88,54.92 85.01,55.04 87.22,55.04
+1V8S5 on IN1 (solid shape): 46.17,75.3 46.17,75.08 45.41,74.32 44.6,74.32 44.19,74.73 44.19,74.93 44.97,75.71 45.77,75.71
+1V8S5 on IN1 (solid shape): 95.25,69.6 95.25,63.32 95.12,63.2 94.38,63.2 94.28,63.3 94.28,64.29 94.36,64.37 94.36,69.6 94.48,69.72 95.12,69.72
+1V8S5 on IN1 (solid shape): outline of 153 points within 56.82,43.41 79.55,49.96
+1V8S5 on IN2 (solid shape): 99.74,76.35 99.74,75.77 99.67,75.69 98.22,75.69 98.17,75.74 98.17,76.33 98.27,76.43 99.67,76.43
+1V8S5 on SVCC2 (solid shape): 101.33,77.28 101.33,77.06 97.83,73.56 81.81,73.56 81.71,73.54 81.63,73.49 79.16,71.02 76.6,71.02 76.51,71 76.42,70.95 75.53,70.06 75.48,69.97 75.46,69.88 75.46,55.38 74.14,54.06 74.08,53.97 74.06,53.87 74.06,51.72 74.08,51.62 74.14,51.54 74.39,51.28 74.47,51.23 74.57,51.21 86.78,51.21 87.4,50.59 87.4,49.16 87.04,48.79 72.52,48.79 71.02,50.3 71.02,59.62 70.94,59.79 70.76,59.87 70.76,61.57 70.96,61.77 71,61.82 71.02,61.88 71.02,64.03 71,64.09 70.96,64.14 70.89,64.21 70.89,64.4 70.98,64.49 71.02,64.62 71.02,77.01 71.38,77.37 101.24,77.37
+1V8S5 on IN3 (solid shape): 87.17,49.66 87.17,48.85 87.14,48.82 85.01,48.82 84.91,48.92 84.91,49.15 85.49,49.73 87.09,49.73
+1V8S5 on IN4 (solid shape): 85.77,49.51 85.77,49.05 86.23,48.59 86.23,48.46 86.15,48.39 85.49,48.39 84.96,48.92 84.96,49.56 85.01,49.61 85.67,49.61
+1V8S5 on IN4 (solid shape): 84.3,59.82 84.3,56.44 85.01,55.73 85.01,55.55 84.83,55.37 84.35,55.37 83.77,55.96 83.77,59.69 83.92,59.84 84.27,59.84
+1V8S5_SOC on TOP (solid shape): 52.35,68.94 52.42,68.86 53.46,68.86 53.54,68.78 53.54,68.45 51.89,68.45 51.81,68.53 51.81,69.7 52.35,69.7
+1V8S5_SOC on BOTTOM (solid shape): 61.67,70.92 61.7,70.9 61.72,70.87 61.72,70.11 61.64,70.03 61.19,70.03 61.08,70.13 59.74,70.13 59.53,70.33 59.53,70.44 60.02,70.92
+1V8S5_SOC on IN1 (solid shape): outline of 302 points within 51.94,66.04 61.59,77.57
+1V8S5_SOC on IN2 (solid shape): 53.12,68.73 53.23,68.71 53.35,68.73 53.36,68.73 53.87,68.73 54,68.61 54,68.1 53.87,67.97 52.09,67.97 51.97,68.1 51.97,68.61 52.09,68.73 53.11,68.73
+1V8S5_SOC on IN3 (solid shape): 54.12,68.61 54.12,68.1 54,67.97 52.22,67.97 52.09,68.1 52.09,68.51 52.32,68.73 54,68.73
+1V8SX on IN1 (solid shape): outline of 201 points within 17.57,38.05 83.33,55.78
+1V8SX on IN3 (solid shape): 18.92,51.69 18.92,49.61 19.05,49.48 20.52,49.48 20.57,49.43 20.57,49.13 20.49,49.05 19.02,49.05 18.95,48.97 18.95,45.72 18.87,45.65 18.44,45.65 18.34,45.75 18.34,50.62 17.52,51.44 17.52,51.92 17.57,51.97 18.64,51.97
+1V8SX on IN4 (solid shape): 83.79,60 83.79,59.97 83.51,59.69 83.51,57.63 83.16,57.28 83.16,55.48 83.13,55.45 82.52,55.45 82.47,55.5 82.47,57.33 83.03,57.89 83.03,59.56 83.56,60.1 83.69,60.1
+1V24 on BOTTOM (solid shape): 84.78,51.33 84.78,49.86 84.48,49.56 84.48,47.27 84.35,47.14 83.21,47.14 83.08,47.27 83.08,49.81 83.61,50.34 83.61,50.8 84.22,51.41 84.71,51.41
+1V24 on IN1 (solid shape): 64.37,63.08 64.37,60.92 65.02,60.28 65.02,58.47 62.66,56.11 58.26,56.11 56.36,54.21 56.36,51.72 60.09,47.98 64.46,47.98 65.16,47.28 68.64,47.28 70.41,45.52 73.56,45.52 75.28,47.25 75.28,48.67 77.49,50.88 79.85,50.88 80.62,50.12 80.62,47.14 81,46.76 81,46.41 80.84,46.25 80.44,46.25 79.83,46.86 79.83,49.89 79.5,50.22 77.57,50.22 76.04,48.69 76.04,46.84 74.01,44.81 70.15,44.81 68.3,46.66 64.92,46.66 64.21,47.37 59.69,47.37 55.62,51.44 55.62,54.54 58.04,56.95 62.53,56.95 64.33,58.75 64.33,59.79 63.33,60.8 63.33,62.88 62.84,63.37 62.84,63.73 63.06,63.96 63.5,63.96
+1V24 on IN2 (solid shape): 85.54,60.96 85.54,60.61 85.49,60.56 85.14,60.56 83.74,59.16 83.74,52.53 84.68,51.59 84.68,50.37 84.55,50.24 84.3,50.24 84.1,50.45 84.1,51.06 83.12,52.03 83.12,53.48 83.11,53.49 83.11,59.77 84.4,61.06 85.44,61.06
+1V24_SOC on BOTTOM (solid shape): 59.41,65.15 59.48,65.06 59.59,65.01 59.6,65.01 59.74,64.87 61.13,64.87 61.26,64.75 62.58,64.75 62.63,64.7 62.63,64.11 62.53,64.01 61.82,64.01 61.79,64.03 61.79,64.11 61.69,64.21 59.95,64.21 59.93,64.25 59.84,64.39 59.67,64.45 59.64,64.46 59.54,64.63 59.4,64.7 59.38,64.7 59.29,64.79 59.28,64.8 59.23,64.87 59.16,64.92 59.15,64.92 59.13,64.95 59.13,65.08 59.15,65.1 59.21,65.13 59.26,65.18 59.39,65.18
+1V24S5 on BOTTOM (solid shape): 81,50.22 81,48.74 80.9,48.64 79.73,48.64 79.24,49.13 79.24,50.17 79.5,50.42 80.79,50.42
+1V24S5 on IN3 (solid shape): 84.11,61.25 84.15,61.25 84.18,61.23 84.18,60.72 84.13,60.67 84.13,58.54 84.41,58.26 84.41,56.43 84.02,56.03 84.02,54.76 83,53.75 82.5,53.75 80.95,52.2 80.95,49.89 80.82,49.76 80.31,49.76 80.24,49.84 80.24,50.5 80.46,50.73 80.46,52.94 81.91,54.38 82.83,54.38 83.46,55.02 83.46,56.31 83.77,56.62 83.77,61.27 83.79,61.29 84.07,61.29
+1V24S5_SOC on BOTTOM (solid shape): 61.64,68.38 61.64,67.97 61.59,67.92 59.63,67.92 59.56,68.01 59.51,68.06 59.49,68.07 59.48,68.1 59.48,68.18 59.71,68.4 61.62,68.4
+1V24SX on IN1 (solid shape): 88.29,52.4 88.29,52.17 88.08,51.97 87.86,51.97 86.33,53.49 79.83,53.49 74.93,48.59 74.93,47.35 73.35,45.77 70.58,45.77 69.26,47.09 69.26,50.92 69.67,50.92 69.67,50.87 69.68,50.83 69.7,50.8 69.73,50.76 69.76,50.73 69.8,50.71 69.83,50.7 69.88,50.69 69.92,50.69 69.96,50.7 70,50.71 70.04,50.73 70.07,50.76 70.09,50.8 70.11,50.83 70.12,50.87 70.13,50.92 70.12,50.96 70.11,51 70.09,51.04 70.07,51.07 70.04,51.1 70,51.12 69.96,51.14 69.92,51.15 69.88,51.15 69.83,51.14 69.8,51.12 69.76,51.1 69.73,51.07 69.7,51.04 69.68,51 69.67,50.96 69.67,50.92 69.26,50.92 69.26,52 69.34,52.07 70.33,52.07 70.61,51.79 70.61,47.35 71.6,46.36 72.87,46.36 74.09,47.58 74.09,48.85 79.37,54.13 86.56,54.13
+1V24SX_SOC on IN1 (solid shape): outline of 150 points within 49.93,60.33 61.41,63.58
+1V_SOC on BOTTOM (solid shape): 64.28,60.45 64.28,59.82 64.23,59.77 63.67,59.77 63.45,59.54 63.45,59.03 63.24,58.83 62.79,58.83 62.68,58.93 61.36,58.93 61.26,59.03 61.26,59.29 61.34,59.36 61.79,59.36 61.87,59.44 61.87,59.92 61.77,60.02 61.39,60.02 61.31,60.1 61.31,60.56 61.34,60.58 64.16,60.58
+1V_SOC on BOTTOM (solid shape): 59.79,63.7 61.19,63.7 61.29,63.6 61.77,63.6 61.77,63.15 61.72,63.1 61.21,63.1 61.16,63.15 61.16,63.25 61.06,63.35 59.56,63.35 59.36,63.15 59.26,63.15 59.21,63.19 59.15,63.23 59.1,63.27 59.1,63.38 59.14,63.39 59.25,63.47 59.3,63.59 59.32,63.62 59.36,63.63 59.5,63.66 59.6,63.76 59.74,63.76
+1V_SOC on BOTTOM (solid shape): 61.64,68.56 61.59,68.51 59.66,68.51 59.55,68.39 59.54,68.39 59.47,68.34 59.41,68.28 59.39,68.26 59.37,68.25 59.25,68.25 59.13,68.38 59.13,68.4 59.46,68.73 59.47,68.74 59.55,68.79 59.61,68.88 59.62,68.89 59.69,68.97 59.74,68.98 59.77,68.99 59.79,69 59.82,69.02 59.86,69.04 61.64,69.04
+1V_SOC on IN1 (solid shape): outline of 614 points within 49.91,58.78 63.31,69.27
+1VS5 on TOP (solid shape): 86.84,59.29 86.84,58.29 86.97,58.17 88.24,58.17 88.29,58.12 88.29,57.53 88.21,57.46 86.28,57.46 86,57.74 86,59.29 86.05,59.34 86.79,59.34
+1VS5 on BOTTOM (solid shape): 94.69,78.23 94.69,77.42 94.43,77.17 94.43,76.76 94.31,76.63 93.29,76.63 93.24,76.68 93.24,78.23 93.29,78.28 94.64,78.28
+1VS5 on BOTTOM (solid shape): 66.04,56.8 66.04,54.05 65.73,53.75 65.73,53.06 65.71,53.04 64.97,53.04 64.36,52.43 62.61,52.43 62.51,52.53 62.51,53.87 63.57,54.94 63.57,56.49 63.93,56.85 65.99,56.85
+1VS5 on BOTTOM (solid shape): 64.61,50.65 70.18,50.65 70.63,50.19 72.29,50.19 72.79,49.69 72.79,49.03 73.02,48.79 73.02,46.43 72.95,46.36 71.55,46.36 71.47,46.43 71.47,47.27 71.78,47.58 71.78,48.69 71.68,48.79 70.63,48.79 70.51,48.67 70.51,48.16 70.13,47.78 67.59,47.78 67.08,48.29 67.08,48.54 66.32,49.3 65.17,49.3 64.31,48.44 62.1,48.44 62,48.54 62,50.83 62.13,50.95 64.31,50.95
+1VS5 on BOTTOM (solid shape): 92.94,77.24 92.94,76.55 92.78,76.25 92.94,75.96 92.94,72.7 92.43,72.19 91.92,72.19 90.88,71.15 90.88,69.75 90.84,69.71 89.81,69.71 89.68,69.84 89.68,72.16 89.91,72.39 91.03,72.39 91.11,72.47 91.11,77.01 91.59,77.5 92.68,77.5
+1VS5 on IN1 (solid shape): outline of 1572 points within 62.43,46.59 94.69,78.36
+1VS5 on IN3 (solid shape): 85.75,66.65 85.75,66.04 85.47,65.76 85.47,64.72 85.37,64.62 85.16,64.62 85.09,64.7 85.09,65.91 85.34,66.17 85.34,66.68 85.39,66.73 85.67,66.73
+1VS5_SOC on TOP (solid shape): 55.24,69.14 55.24,68.76 55.34,68.66 58.77,68.66 59.84,67.59 60.86,67.59 61.06,67.39 61.06,66.52 60.98,66.45 59.97,66.45 58.39,68.02 54.35,68.02 54.33,68.05 54.33,68.71 54.38,68.76 54.78,68.76 54.86,68.84 54.86,69.19 54.91,69.24 55.14,69.24
+1VS5_SOC on BOTTOM (solid shape): 55.8,68.56 55.8,68.33 55.7,68.23 55.17,68.23 55.06,68.12 55.06,67.87 55.01,67.82 54.71,67.82 54.66,67.87 54.66,68.23 54.63,68.25 54.45,68.25 54.4,68.3 54.4,68.56 54.45,68.61 55.75,68.61
+1VS5_SOC on BOTTOM (solid shape): 61.64,66.83 59.6,66.83 59.56,66.88 59.51,66.92 59.48,66.94 59.48,67.05 59.52,67.08 59.58,67.16 59.97,67.16 60.19,67.39 61.64,67.39
+1VS5_SOC on IN2 (solid shape): 55.24,69.14 55.24,69.06 55.52,68.78 55.52,68.48 55.17,68.12 54.35,68.12 54.3,68.18 54.3,68.66 54.4,68.76 54.78,68.76 54.94,68.91 54.94,69.17 54.99,69.22 55.17,69.22
+1VS5_SOC on IN3 (solid shape): 55.55,68.81 55.55,68.71 55.77,68.48 55.77,68.38 55.7,68.3 55.34,68.3 54.89,67.85 54.76,67.85 54.4,68.2 54.4,68.48 54.68,68.76 54.73,68.78 54.84,68.78 54.99,68.94 55.42,68.94
+1VSX on BOTTOM (solid shape): 62.38,52.25 64.77,52.25 65.17,51.84 65.76,51.84 65.83,51.77 66.57,51.77 66.65,51.84 69.19,51.84 69.21,51.82 69.39,51.82 69.49,51.72 69.49,50.95 69.36,50.83 64.77,50.83 64.46,51.13 64.46,51.41 64.28,51.59 60.47,51.59 60.22,51.33 58.63,51.33 58.61,51.39 58.43,51.56 58.2,51.46 57.67,51.46 57.3,51.08 55.11,51.08 54.86,50.83 53.9,50.83 53.9,52.22 53.93,52.25 57.17,52.25 57.19,52.24 57.38,52.19 57.56,52.24 57.58,52.25 58.24,52.25 58.26,52.24 58.44,52.19 58.62,52.24 58.64,52.25 58.7,52.25 58.79,52.35 58.87,52.37 58.94,52.34 59.24,52.23 59.51,52.4 59.84,52.73 61.9,52.73
+1VSX_S on BOTTOM (solid shape): 69.36,59.21 69.36,57.18 69.24,57.05 68.73,57.05 68.6,57.18 68.6,57.68 68.17,58.12 68.17,59.49 68.27,59.59 68.98,59.59
+1VSX_S on BOTTOM (solid shape): 60.35,50.7 61.36,50.7 61.62,50.45 61.62,48.72 61.31,48.41 59.64,48.41 59.61,48.44 55.5,48.44 55.34,48.59 55.34,50.4 55.52,50.57 57.05,50.57 57.3,50.32 57.3,49.81 57.43,49.68 58.7,49.68 59.33,50.32 59.33,50.7 59.59,50.95 60.09,50.95
+1VSX_S on IN4 (solid shape): outline of 207 points within 58.53,47.47 69.49,58.07
+1VSX_S_SOC on BOTTOM (solid shape): 49.27,56.57 49.27,56.47 49.07,56.26 49.07,56.19 48.59,55.7 48.59,54.15 48.59,53.72 48.66,53.65 50.14,53.65 50.19,53.6 50.19,52.4 50.31,52.27 51.48,52.27 51.56,52.2 51.56,51.33 52.4,50.5 54.84,50.5 54.95,50.38 54.95,48.48 54.89,48.41 52.52,48.41 52.14,48.79 52.14,49.76 51.97,49.94 51.03,49.94 50.77,50.19 50.77,51.44 50.64,51.56 49.81,51.56 49.58,51.79 49.58,53.14 49.43,53.29 48.05,53.29 48.03,53.32 48.03,56.06 48.13,56.16 48.13,56.21 48.23,56.31 48.31,56.31 48.43,56.19 48.66,56.19 48.82,56.34 48.82,56.42 49.07,56.67 49.17,56.67
+1VSX_S_SOC on BOTTOM (solid shape): 48.94,74.75 48.94,74.22 48.93,74.22 48.93,73.66 48.94,73.66 48.94,72.43 49.12,72.26 49.12,72.03 49.15,72 49.15,71.99 49.17,71.98 49.27,71.9 49.27,71.77 49.26,71.74 49.22,71.7 49.2,71.66 49.19,71.63 49.04,71.63 49.02,71.66 48.97,71.74 48.89,71.79 48.88,71.79 48.8,71.87 48.8,71.89 48.61,72.12 48.33,72.01 48.32,71.99 48.23,71.99 48.19,72 48.13,72.05 48.07,72.08 48.06,72.08 48,72.14 48,72.94 47.95,72.99 47.95,73 47.9,73.05 47.9,74.78 47.95,74.83 48.87,74.83
+1VSX_S_SOC on IN1 (solid shape): outline of 292 points within 44.9,49.23 53.67,74.78
+1VSX_S_SOC on IN3 (solid shape): 48.36,66.14 48.36,64.57 48.28,64.49 47.85,64.49 47.75,64.59 47.75,65.79 48.05,66.09 48.05,66.17 48.1,66.22 48.28,66.22
+1VSX_SOC on BOTTOM (solid shape): 59.4,62.33 59.56,62.19 59.78,62.2 59.79,62.21 60.63,62.21 61.69,62.21 61.77,62.13 61.77,61.27 61.69,61.19 61.24,61.19 61.15,61.09 60.89,61.09 60.24,61.75 59.59,61.75 59.49,61.84 59.36,61.87 59.34,61.87 59.27,61.94 59.26,61.95 59.22,62.04 59.15,62.11 59.13,62.13 59.13,62.24 59.15,62.25 59.2,62.29 59.23,62.33 59.25,62.36 59.39,62.36
+1VSX_SOC on BOTTOM (solid shape): 52.6,56.66 52.64,56.6 52.7,56.55 52.7,56.44 52.59,56.37 52.52,56.27 52.52,56.26 52.5,56.24 52.5,55.86 52.57,55.78 52.57,54.18 52.8,53.95 52.8,53.14 52.96,52.99 53.57,52.99 53.72,52.83 53.72,52.58 53.57,52.43 53.57,50.8 53.44,50.67 52.52,50.67 51.74,51.46 51.74,53.93 51.86,54.05 52,54.05 52.1,54.15 52.1,55.97 52.04,56.03 52.04,56.2 52.07,56.23 52.17,56.33 52.2,56.47 52.21,56.5 52.24,56.52 52.35,56.57 52.42,56.66 52.43,56.69 52.58,56.69
+1VSX_SOC on BOTTOM (solid shape): 57.55,74.2 57.55,72.15 57.53,72.12 57.52,72.12 57.4,72.02 57.35,71.88 57.35,71.86 57.29,71.8 57.28,71.8 57.19,71.75 57.13,71.66 57.11,71.64 57.08,71.63 56.99,71.63 56.97,71.64 56.95,71.66 56.92,71.71 56.88,71.75 56.85,71.83 56.9,71.91 57.04,72.11 56.98,72.34 56.98,72.56 57.27,72.86 57.27,74.17 57.29,74.21 57.32,74.22 57.53,74.22
+1VSX_SOC on BOTTOM (solid shape): 56.71,74.03 56.71,72.93 56.52,72.75 56.52,72.34 56.48,72.26 56.46,72.17 56.45,72.14 56.42,72.13 56.27,72.04 56.2,71.8 56.14,71.77 56.04,71.73 55.97,71.65 55.97,71.64 55.94,71.63 55.88,71.63 55.85,71.64 55.84,71.65 55.81,71.69 55.77,71.72 55.75,71.74 55.75,71.76 55.75,71.87 55.76,71.89 55.87,72.01 55.91,72.13 55.91,72.15 56.11,72.34 56.11,74.12 56.13,74.14 56.59,74.14
+1VSX_SOC on IN1 (solid shape): outline of 504 points within 46.78,50.78 60.7,74.5
+1VSX_SOC on IN3 (solid shape): 54.91,62.94 54.97,62.93 54.99,62.92 55.25,62.92 55.26,62.92 55.47,62.92 55.67,62.71 55.67,61.98 55.78,61.88 55.78,61.7 55.71,61.63 55,61.63 54.96,61.67 54.96,62.36 54.78,62.54 53.9,62.54 53.84,62.59 53.84,62.79 53.95,62.89 54.71,62.89 54.74,62.92 54.84,62.92 54.86,62.93
+2.85V_EMMC on TOP (solid shape): 35.35,39.17 35.35,38.46 35.48,38.33 38.78,38.33 38.93,38.18 38.93,37.36 38.48,36.91 35.48,36.91 35.02,37.37 35.02,37.38 35.01,37.38 34.87,37.52 34.41,37.52 34.24,37.7 34.24,39.22 34.25,39.26 34.29,39.27 35.25,39.27
+2.85V_EMMC on BOTTOM (solid shape): outline of 142 points within 33.63,35.54 37.13,38.97
+2V85 on TOP (solid shape): 92.73,60.71 92.73,51.11 91.39,49.76 87.88,49.76 87.14,49.02 83.05,49.02 82.78,48.74 82.78,41.25 84.27,39.75 84.27,35.49 82.83,34.04 46.35,34.04 41.73,38.66 38.2,38.66 38.07,38.79 38.07,39.63 38.3,39.85 42.82,39.85 47.55,35.13 82.34,35.13 83.21,35.99 83.21,39.35 81.73,40.82 81.73,49.2 82.65,50.12 84.83,50.12 85.09,50.37 86.51,50.37 87.3,51.16 88.11,51.16 88.67,51.72 88.67,54.13 89.05,54.51 89.05,55.02 89.68,55.65 91.61,55.65 91.87,55.91 91.87,59.59 91.59,59.87 90.34,59.87 89.94,60.28 89.3,60.28 89.3,60.81 89.35,60.86 92.58,60.86
+2V85 on BOTTOM (solid shape): 94.61,55.02 94.61,51.03 94.21,50.62 91.34,50.62 91.21,50.75 91.21,51.46 91.26,51.51 93.16,51.51 93.37,51.72 93.37,55.02 93.49,55.14 94.48,55.14
+2V85 on BOTTOM (solid shape): 89.07,60.15 89.07,59.51 89.51,59.08 92.83,59.08 93.24,58.68 93.24,54.28 93.14,54.18 92.17,54.18 92.07,54.28 92.07,57.91 91.89,58.09 89.48,58.09 88.21,59.36 88.21,60.3 87.5,61.01 87.19,61.01 87.14,61.06 87.14,61.24 87.19,61.29 87.93,61.29
+2V85 on IN3 (solid shape): 86.99,62.1 88.29,62.1 89.05,61.34 89.61,61.34 89.76,61.19 89.76,61.04 89.63,60.91 88.85,60.91 88.16,61.6 87.04,61.6 86.38,62.26 86.38,62.43 86.41,62.46 86.64,62.46
+3.3V_PA on TOP (solid shape): 162.96,78.23 162.96,76.84 162.84,76.71 161.82,76.71 161.44,76.33 160.3,76.33 160.17,76.46 160.17,77.73 160.42,77.98 160.93,77.98 161.06,78.11 161.06,78.23 161.31,78.49 162.71,78.49
+3V3 on TOP (solid shape): 114.65,52.68 114.65,52.15 114.5,52 112.26,52 112.19,52.07 112.19,52.66 112.29,52.76 114.58,52.76
+3V3 on TOP (solid shape): 58.77,52.6 58.77,52.27 54.81,48.31 50.7,48.31 50.62,48.39 50.62,48.92 50.85,49.15 54.66,49.15 58.32,52.81 58.57,52.81
+3V3 on TOP (solid shape): 53.24,40.21 55.42,40.21 55.42,38.43 55.39,38.43 55.39,38.13 55.27,38 54.76,38 54.38,38.38 54.38,39.02 54.17,39.22 50.49,39.22 50.31,39.4 50.31,40.16 50.57,40.41 53.03,40.41
+3V3 on BOTTOM (solid shape): 58.59,53.72 58.59,52.4 58.57,52.38 57.93,52.38 57.83,52.48 57.83,53.14 57.71,53.27 55.85,53.27 55.85,53.75 55.88,53.77 58.54,53.77
+3V3 on BOTTOM (solid shape): 28.39,16.92 28.39,15.52 28.8,15.11 28.8,14.81 28.67,14.68 27.94,14.68 27.78,14.84 27.78,16.9 27.86,16.98 28.33,16.98
+3V3 on BOTTOM (solid shape): 115.32,54.67 116.26,54.67 116.81,54.12 116.81,53.7 116.58,53.47 116.27,53.47 115.83,53.91 115.09,53.91 114.87,54.13 114.87,54.46 115.09,54.68 115.32,54.68
+3V3 on BOTTOM (solid shape): 7.13,71.6 7.13,70.64 5.74,69.24 5.74,64.95 6.45,64.24 7.44,64.24 7.52,64.16 7.52,63.15 7.39,63.02 6.5,63.02 5,64.52 5,69.57 6.63,71.2 6.63,71.63 6.73,71.73 7.01,71.73
+3V3 on BOTTOM (solid shape): 103.6,63.65 103.6,61.37 103.48,61.24 100.28,61.24 100.15,61.37 100.15,61.72 99.97,61.9 99.97,62.79 100.17,62.99 100.61,62.99 100.89,63.27 100.89,63.68 100.99,63.78 101.42,63.78 101.47,63.79 101.54,63.81 103.45,63.81
+3V3 on IN1 (solid shape): 52.47,48.67 52.47,46 48.41,41.94 47.77,41.94 47.57,42.14 47.57,43.28 50.59,46.31 50.59,48.67 50.7,48.77 52.37,48.77
+3V3 on IN1 (solid shape): 116.35,54.15 113.86,51.66 113.73,51.61 113.62,51.68 113.27,51.71 113.3,51.36 113.37,51.25 113.33,51.13 112.93,50.73 108.45,50.73 102.59,44.86 101.06,44.86 100.96,44.96 100.96,46.2 101.11,46.36 102.33,46.36 107.62,51.64 112.39,51.64 114.96,54.21 114.96,54.46 115.11,54.61 116.35,54.61
+3V3 on IN1 (solid shape): outline of 95 points within 6.25,14.35 28.71,64.16
+3V3 on IN2 (solid shape): 87.19,62.97 87.19,62.69 87.14,62.64 87.14,62.38 87.32,62.21 93.99,62.21 94.02,62.17 97.02,62.17 97.2,62.1 97.39,62.17 99.04,62.17 99.07,62.21 99.39,62.21 99.74,62.56 101.27,62.56 101.39,62.43 101.39,61.79 101.28,61.67 100.33,61.67 100.05,61.39 98.09,61.39 98.08,61.4 97.96,61.42 97.84,61.4 97.84,61.39 89.78,61.39 89.75,61.42 89.34,61.42 89.31,61.39 87.25,61.39 86.64,62 86.64,62.92 86.76,63.04 87.12,63.04
+3V3 on SVCC2 (solid shape): 48.86,42.14 48.95,42.08 49.04,42.06 86.66,42.06 86.89,41.83 86.89,40.9 85.13,39.14 17.27,39.14 16.81,39.61 16.81,41.63 16.79,41.66 16.79,41.7 17.27,42.19 44.09,42.19 44.19,42.21 44.27,42.26 46.23,44.22 46.78,44.22
+3V3 on SVCC2 (solid shape): outline of 627 points within 6.12,36.86 140.1,86.92
+3V3_LCM on TOP (solid shape): 54.63,37.87 55.27,37.87 55.39,37.75 55.39,37.52 55.8,37.11 56.54,37.11 56.59,37.06 56.59,35.76 56.51,35.69 55.93,35.69 55.83,35.79 55.83,36.22 55.57,36.48 52.85,36.48 52.73,36.6 52.73,38 52.85,38.13 54.38,38.13
+3V3_LCM on BOTTOM (solid shape): 54.61,37.01 54.61,36.11 54.5,36 54.5,35.2 54.49,35.19 54.22,35.19 54.22,36 54.18,36.04 53.92,36.04 53.89,36.01 53.89,35.19 53.6,35.19 53.6,36.08 53.49,36.19 53.49,36.22 53.36,36.35 53.36,36.98 53.49,37.11 54.51,37.11
+3V3_NGFF on BOTTOM (solid shape): 34.44,11.71 34.44,11.46 34.06,11.08 34.06,10.69 33.93,10.57 33.55,10.57 33.42,10.69 33.42,11.08 33.68,11.33 33.68,11.58 33.93,11.84 34.31,11.84
+3V3_NGFF on BOTTOM (solid shape): 20.77,7.27 20.77,6.86 20.44,6.53 20.44,5.01 20.15,5.01 20.15,6.52 19.94,6.52 19.94,5.01 19.65,5.01 19.65,6.51 19.44,6.51 19.44,5.01 19.15,5.01 19.15,6.5 19.02,6.63 18.77,6.63 18.61,6.78 18.61,7.27 18.72,7.37 20.67,7.37
+3V3_NGFF on BOTTOM (solid shape): 25.04,23.65 25.04,19.94 24.79,19.69 24.79,19.28 24.86,19.2 24.86,17.88 24.15,17.17 24.15,9.68 23.86,9.39 21.42,9.39 21.13,9.68 21.13,12.12 21.23,12.22 21.56,12.22 21.82,12.47 21.82,12.96 21.46,13.31 21.46,17.91 21.76,18.21 22.93,18.21 23.11,18.39 23.11,19.13 22.78,19.46 21.97,19.46 21.84,19.58 21.84,23.73 22.04,23.93 24.76,23.93
+3V3_NGFF on BOTTOM (solid shape): outline of 90 points within 36.65,4.37 43,9.98
+3V3_NGFF on IN4 (solid shape): outline of 562 points within 18.59,5.58 40.74,11.69
+3V3_SD_SW on IN2 (solid shape): 135.4,71.91 135.4,70.84 135.1,70.54 134.79,70.54 134.69,70.64 134.69,71.58 134.49,71.78 129.77,71.78 129.38,71.4 129.17,71.29 129.06,71.07 128.8,70.82 128.57,70.82 128.39,70.99 128.39,71.4 129.33,72.34 134.97,72.34
+3V3PCU on TOP (solid shape): 153.18,84.48 153.18,83.72 153.06,83.59 152.17,83.59 152.04,83.72 152.04,84.35 151.91,84.48 151.53,84.48 151.28,84.74 151.28,84.99 151.41,85.12 152.55,85.12
+3V3PCU on BOTTOM (solid shape): 110,64.03 110,63.25 109.88,63.12 107.41,63.12 107.26,63.27 107.26,64.03 107.36,64.14 109.62,64.14 109.64,64.15 109.89,64.15
+3V3PCU on IN1 (solid shape): 121.31,58.32 121.31,57.81 121.05,57.56 118.77,57.56 118.64,57.68 118.64,58.32 118.89,58.57 121.05,58.57
+3V3PCU on IN1 (solid shape): 153.06,83.85 153.06,83.47 152.93,83.34 151.79,83.34 151.66,83.47 151.66,83.97 151.79,84.1 152.8,84.1
+3V3PCU on IN2 (solid shape): 104.19,59.72 104.19,59.06 104.92,58.32 107.57,58.32 109.34,56.54 110.33,56.54 111.71,55.17 113.86,55.17 114.55,54.48 114.55,54.15 114.45,54.05 114.17,54.05 113.61,54.61 111.27,54.61 109.98,55.91 109.01,55.91 107.21,57.71 104.82,57.71 103.7,58.83 103.7,59.59 103.32,59.97 102.28,59.97 102.16,60.1 102.16,60.33 102.33,60.5 103.4,60.5
