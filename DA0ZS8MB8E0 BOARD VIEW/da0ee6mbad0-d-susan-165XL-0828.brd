# Allegro board da0ee6mbad0-d-susan-165XL-0828.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
V1.0S_EN: length 73.7
  TOP w0.114: v13(71.47,55.12) 72.23,55.12 72.81,54.55 v5(72.81,54.51)
  IN2 w0.064: v4(72.03,56.8) 72.03,55.21 72.72,54.51 v5(72.81,54.51)
  IN3 w0.06: 86.28,66.14 86.28,65.86 86.41,65.74 86.41,65.08 86.08,64.75 v8(85.68,64.75)
  IN3 w0.064: 86.28,66.14 86.28,66.55 87.86,68.12 88.59,68.12 89.35,68.89 89.73,68.89 90.69,69.84 90.69,70.07 91.97,71.35 94.15,71.35 95.81,69.7 95.81,64.22 96.76,63.26 96.76,60.19 92.35,55.78 90.27,55.78 88.81,54.32 88.81,51.73 87.58,50.5 85.48,50.5 84.67,49.68 82.55,49.68 81.21,48.34 79.94,48.34 76.31,51.98 76.31,53.41 76,53.72 74.11,53.72 73.76,53.37 73.76,53.08 73.54,52.86 71.52,52.86 68.01,56.38 v1(68.01,56.54) 68.11,56.64 69.14,56.64 69.66,57.17 70.36,57.17 70.73,56.8 v4(72.03,56.8)
V1.0S_SENSE: length 52.9
  TOP w0.254: v5(90.67,66.8) 90.7,66.83 90.7,69.78 v13(90.37,70.11) 90.37,72.42 v5(90.7,72.75)
  IN2 w0.254: v4(89.81,66.55) 90.07,66.8 v5(90.67,66.8) ; v5(90.7,72.75) 90.55,72.59 84.48,72.59 81.48,69.6 80.54,69.6 80.21,69.27 80.21,68.89 79.32,68 79.32,66.5 79.19,66.37 79.19,65.89 79.31,65.77 79.77,65.77 80.29,65.26 80.29,62.76 80.04,62.52 80.04,61.3 80.16,61.19 80.16,60.07 79.85,59.77 79.5,59.77 v4(79.09,60.17)
  IN3 w0.254: v4(89.81,66.55) 89.76,66.55 89.18,65.97 89.18,65.05 89.02,64.9 v11(88.69,64.9) ; v4(79.09,60.17) 79.04,60.17 78.99,60.12 77.01,60.12 76.34,59.45 71.46,59.45 69.67,57.66 v1(69.67,57.58)
  IN4 w0.203: 86.86,64.29 86.65,64.07 86.35,64.07 v8(86.08,64.35)
  IN4 w0.254: v11(88.69,64.9) 88.69,64.82 88.16,64.29 86.86,64.29
  BOTTOM w0.254: PR58.1 69.07,60.01 69.67,59.41 v1(69.67,57.58)
V1.0SX_EN: length 63.8
  TOP w0.114: U7.2 73.31,51.97 v5(73.33,51.94)
  IN2 w0.064: v4(73.56,50.83) 73.56,51.72 v5(73.33,51.94) 73.56,52.17 73.56,53.01 v4(73.35,53.21)
  IN3 w0.064: v8(73.81,50.32) 73.56,50.57 v4(73.56,50.83) ; v4(73.35,53.21) 73.35,53.29 73.93,53.87 76.1,53.87 76.46,53.51 76.46,52.04 80.01,48.5 81.11,48.5 82.45,49.84 84.6,49.84 85.42,50.65 87.51,50.65 88.66,51.79 88.66,54.4 90.24,55.98 92.27,55.98 96.61,60.32 96.61,63.2 95.6,64.21 95.6,69.6 94,71.2 92.1,71.2 91.59,70.69 91.59,68.76 90.34,67.51 v11(88.34,67.51)
  IN4 w0.07: 86.03,66.19 86.03,65.71 85.68,65.36 v8(85.68,65.15)
  IN4 w0.127: 86.03,66.19 87.21,67.38 88.2,67.38 v11(88.34,67.51)
  BOTTOM w0.114: v8(73.81,50.32) 73.3,50.32 v13(73.05,50.57) 72.92,50.7 PR77.2
V1.0SX_SENSE: length 66.7
  IN3 w0.064: v1(69.59,55.14) 69.74,55.14 70.87,54.02 76.16,54.02 76.72,53.46 76.72,51.99 80.07,48.65 81.03,48.65 82.37,49.99 84.5,49.99 85.32,50.8 87.45,50.8 88.5,51.86 88.5,54.55 90.19,56.24 92.27,56.24 96.46,60.42 96.46,63.12 95.25,64.33 95.25,68.35 94.89,68.71 93.72,68.71 92.99,67.97 92.99,64.19 92.86,64.06 90.8,64.06 90.27,64.59 90.27,64.67 90.22,64.72 v11(90.22,64.77)
  IN4 w0.178: 87.03,63.95 86.91,63.82 86.2,63.82 v8(86.08,63.95)
  IN4 w0.254: 87.03,63.95 88.45,63.95 89.28,64.77 v11(90.22,64.77)
  BOTTOM w0.114: v1(69.59,55.14) v13(69.59,54.26) 69.49,54.26 69.31,54.43 69.31,54.79 68.96,55.14 66.95,55.14 66.72,54.92 66.72,52.8 PR60.1
V3.3S_EN_B: length 29.4
  IN3 w0.06: 87.45,63.63 86.56,63.63 v8(86.08,63.15)
  IN3 w0.064: v11(96.21,63.02) 94.97,64.26 94.97,68.3 94.74,68.53 93.98,68.53 93.29,67.84 93.29,63.93 93.19,63.83 88.85,63.83 88.64,63.63 87.45,63.63
  IN3 w0.305: v1(104.64,61.55) 102.13,64.06 v1(101.42,64.06)
  IN4 w0.127: v1(97.91,63.98) 97.89,63.96 97.89,63.6 97.3,63.02 v11(96.21,63.02)
  BOTTOM w0.114: v1(97.91,63.98) 97.99,63.98
  BOTTOM w0.381: v1(101.42,64.06) v13(99.74,64.06) 98.07,64.06 97.99,63.98
VCC_FG: length 9.3
  TOP w0.114: v9(119.2,42.5) 119.55,42.5 119.91,42.85 PR32.1 120.32,43.57 120.32,44.5 TP23.1
  TOP w0.254: PU1.D1 117.54,46.26 PC30.2
  TOP w0.508: PC30.2 116.77,44.98 v9(117.14,44.98)
  BOTTOM w0.508: v9(117.14,44.98) 117.14,44.93 119.2,42.88 v9(119.2,42.5)
VCCA_PWROK: length 49.4
  IN3 w0.06: 81.51,63.51 81.57,63.51 81.58,63.5 83.23,63.5 v8(83.28,63.55)
  IN3 w0.064: 81.51,63.51 81.49,63.51 79.4,65.6 77.92,65.6 v11(77.7,65.38)
  IN4 w0.06: v8(44.87,64.16) 45.15,64.16 45.36,64.37 45.52,64.37 45.63,64.25 45.8,64.25 45.92,64.36 45.92,64.37 46.08,64.37 46.08,64.36 46.2,64.25 46.37,64.25 46.49,64.37 46.65,64.37 46.81,64.2 46.9,64.2 47.13,63.97 47.13,63.58 47.58,63.13 47.58,62.55 47.42,62.38 47.42,62.16 47.62,61.95 47.62,61.65 47.37,61.39 47.37,61.24 47.93,60.68 47.93,60.3 48.13,60.1 56,60.1 56.38,59.72 57.52,59.72 57.8,59.43 57.97,59.43 58.1,59.56 58.24,59.56 58.25,59.55 58.42,59.39 58.9,59.39 59.66,60.15 59.66,63.96 60.45,64.75 60.98,64.75
  IN4 w0.127: 60.98,64.75 62.61,64.75 63.52,65.66 v1(63.78,65.66) 77.37,65.66 77.64,65.38 v11(77.7,65.38)
  BOTTOM w0.114: v13(64.28,65.41) 64.03,65.66 v1(63.78,65.66)
VDD1P2_GRF: length 4.7
  IN4 w0.254: v1(32.74,21.84) 32.99,21.58 v1(32.99,20.64)
  BOTTOM w0.254: U22.E5 v1(32.99,20.64) 33.67,20.64 L7.1 34.87,20.89 C214.2 ; v1(32.74,21.84) U22.E2
VDD_1V8_AUDIO: length 31.8
  TOP w0.508: R383.1 v9(124.1,80.75)
  IN1 w0.305: v9(113.56,80.8) 112.8,80.8 110.93,78.93 110.93,78.22 111.4,77.75 111.4,74.55 113.05,72.9 113.05,70.97 112.42,70.33 108.99,70.33 108.73,70.08 v2(108.73,69.66)
  IN4 w0.508: v9(113.56,80.8) 114.07,80.8 114.79,81.52 116.36,81.52 v1(116.36,81.52) 116.93,82.09 118.01,82.09 118.41,81.69 v1(118.89,81.69) 118.92,81.69 119.41,82.18 119.41,82.56 119.76,82.91 121.03,82.91 121.41,82.53 122.83,82.53 124.1,81.26 v9(124.1,80.75)
VDD_1V8_MIC1: length 8.1
  TOP w0.508: v9(19.24,83.39) 19.24,83.58 17.91,84.91 U2.6
  BOTTOM w0.508: C152.2 L5.1 C147.2 19.22,82.59 19.22,83.11 v9(19.24,83.39) 17.57,83.39 17.17,82.98 R212.1
VDDI_DSC: length 4.5
  IN4 w0.254: v1(37.83,34.23) v1(37.83,33.37)
  BOTTOM w0.254: C225.2 37.96,30.9 37.83,31.03 v1(37.83,33.37)
VIN_LDO: length 5
  BOTTOM w0.254: U36.C1 153.96,81.01 153.72,81.26 150.54,81.26 149.97,81.83 149.97,82.3
3G_ON: length 127.6
  TOP w0.114: U12.G2 117.57,60.81 116.46,60.81 v5(116.35,60.71)
  IN2 w0.064: v4(41.73,34.49) 43.99,36.76 50.19,36.76 50.7,36.25 57.2,36.25 57.33,36.38 61.46,36.38 61.6,36.24 73.92,36.24 74.06,36.38 80,36.38 80.64,35.74 84.35,35.74 87.96,39.35 87.96,41.99 88.84,42.88 88.84,49.13 88.34,49.63 86.2,49.63 85.72,50.12 85.72,52.02 85.82,52.12 86.26,52.12 93.17,59.04 98.83,59.04 100.71,60.91 101.89,60.91 102.12,61.14 103.73,61.14 104.46,60.41 107.31,60.41 109.14,58.57 110.74,58.57 111.12,58.19 111.78,58.19 112.11,58.52 112.81,58.52 114.06,59.77 115.1,59.77 115.75,60.42 116.07,60.42 v5(116.35,60.71)
  IN3 w0.064: v1(25.04,33.3) 25.7,33.3 26.13,33.73 34.45,33.73 35.91,32.27 39.89,32.27 41.73,34.11 v4(41.73,34.49)
  BOTTOM w0.114: v1(25.04,33.3) 22.98,33.3 22.59,32.91 PR47.1 22.37,30.67 PQ5.2
24190_SCL: length 2.5
  BOTTOM w0.114: PR117.1 105.04,58.78 PU7.5
24190_SDA: length 2.7
  BOTTOM w0.114: PR118.1 105.54,58.26 PU7.6
24192_BTST: length 2.3
  BOTTOM w0.254: PU7.21 100.32,54.64 PC121.2
24192_OTG: length 5.8
  BOTTOM w0.114: PR137.1 109.03,58.75 108.02,58.75 107.68,58.41 PR123.2 PR124.1 106.96,56.71 106.96,55.78 106.82,55.64 PU7.8
63020_EN: length 115.8
  TOP w0.114: v5(85.7,43.31) 85.7,42.49 85.87,42.32 Q24.5 ; v5(67.03,82.73) 67.03,80.77 66.8,80.54 R87.2
  IN2 w0.064: v4(69.29,83.64) 69.21,83.72 68.02,83.72 v5(67.03,82.73) ; v5(85.7,43.31) 87.63,43.31 v4(88.46,44.15) 88.46,48.08 88.24,48.31 v4(88.24,49.18) ; v4(111.3,69.67) 111.3,70.24 109.71,71.83 v4(108.84,71.83)
  IN3 w0.064: v4(88.46,44.15) 88.41,44.1 v1(88.03,44.1) ; v4(88.24,49.18) 88.26,49.2 98.83,49.2 98.93,49.3 98.93,51.61 101.62,54.31 101.62,57.3 101.27,57.66 101.27,59.59 101.52,59.84 103.5,59.84 104.34,59.01 104.9,59.01 105.1,59.21 105.1,59.95 107.16,62 108.68,62 109.5,62.83 109.5,66.9 111.3,68.7 v4(111.3,69.67) ; v4(69.29,83.64) 69.67,83.26 69.67,82.27 70.18,81.76 80.92,81.76 81.15,81.99 86.08,81.99 86.66,81.41 86.66,78.32 87.39,77.59 87.39,77.15 87.26,77.03 87.26,76.67 87.45,76.48 87.88,76.48 88.03,76.63 88.39,76.63 89.15,75.87 97.51,75.87 97.98,75.4 98.88,75.4 100.02,76.54 103.25,76.54 107.78,72.01 v1(108.43,72.01) 108.66,72.01 v4(108.84,71.83)
  BOTTOM w0.114: v1(88.03,44.1) 87.69,43.75 PR100.2
  BOTTOM w0.254: PR133.2 PR134.1 PC133.2 109.19,75.34 108.68,74.83 108.68,74.44 108.07,73.83 108.07,72.14 108.19,72.02 PU8.6
63020_FB: length 3.8
  BOTTOM w0.254: PR132.1 108.44,66.78 PR136.2 PC134.1 108.44,68.95 108.85,69.35 108.85,69.88 108.7,70.02 PU8.10
63020_FB_S: length 5.5
  BOTTOM w0.254: PR143.1 108.48,64.67 109.28,65.47 PR136.1 PC134.2
63020_PS: length 3
  BOTTOM w0.254: PU8.7 109.32,71.52 PR135.2 110.37,72.56 110.37,73.12 PR144.2
+V_CH_REGN: length 16.3
  IN2 w0.254: v4(100.15,54.81) 102.33,52.63 107.08,52.63 109.24,54.79 v4(109.24,55.37)
  IN3 w0.254: v1(100.15,55.37) v4(100.15,54.81) ; v4(109.24,55.37) 109.5,55.63 110,55.63 v1(110.16,55.78)
  BOTTOM w0.254: PU7.22 100.4,55.14 PC119.2 ; PR141.2 PR140.2
+V_SFR0: length 2.7
  IN2 w0.254: v12(49.11,68.56) 49.11,68.98 v5(49.25,69.11) ; v12(50.16,55.65) v5(50.16,56.08)
  IN3 w0.254: v12(49.11,68.56) 49.11,68.61 v1(49.11,68.97) ; v12(50.16,55.65) v1(50.16,54.38)
+V_SFR1: length 4.1
  IN2 w0.254: v5(52.42,64.91) 52.45,64.91 52.73,64.64 v12(52.78,64.64) ; v12(60.78,65.36) 60.8,65.33 v5(60.8,64.82) ; v5(54.25,63.65) 54.61,63.3 v12(54.97,63.3) ; v12(47.95,68.03) 47.85,68.12 v5(47.85,68.48)
  IN3 w0.254: v12(52.78,64.64) 52.73,64.64 52.72,64.64 v1(52.35,64.64) ; v12(54.97,63.3) 55.28,63.3 v1(55.37,63.21) ; v1(47.95,68.45) 47.95,68.08 v12(47.95,68.03) ; v1(61.19,65.33) 61.16,65.36 v12(60.78,65.36)
  vias: v2(60.8,64.44)
+V_VCC:
  vias: v1(49.87,67.97) v1(49.87,67.02) v1(49.87,64.16) v1(50.15,67.5) v1(50.15,66.54) v1(50.15,64.64) v1(50.15,63.69) v1(50.42,67.97) v1(50.42,67.02) v1(50.42,66.07) v1(50.42,65.11) v1(50.42,64.16) v1(50.42,63.21) v1(50.7,66.54) v1(50.7,64.64) v1(50.7,62.73) v1(50.97,67.97) v1(50.97,66.07) v1(50.97,65.11) v1(50.97,63.21) v1(51.25,68.45) v1(51.25,67.5) v1(51.25,66.54) v1(51.25,64.64) v1(51.25,63.69) v1(51.25,62.73) v1(51.52,67.97) v1(51.52,67.02) v1(51.52,64.16) v1(51.52,63.21) v1(51.66,69.26) v1(51.8,68.45) v1(51.8,67.5) v1(51.8,63.69) v1(51.94,68.97) v1(52.23,69.26) v1(52.51,71.24) v1(52.51,70.67) v1(52.51,70.1) v1(52.51,69.54) v1(52.51,68.97) v1(52.79,70.39) v1(52.79,69.82) v1(52.79,69.26) v2(51.34,67.34) v2(51.34,66.7) v2(51.39,68.61) v2(51.38,64.61) v2(51.36,63.21) v3(51.34,67.34) v3(51.34,66.7) v3(51.39,68.61) v3(51.38,64.61) v3(51.36,63.21) v5(51.34,67.34) v5(51.34,66.7) v5(51.39,68.61) v5(51.38,64.61) v5(51.36,63.21) v6(52.79,70.95) v7(52.79,70.95) v8(52.79,70.95) v10(49.87,64.16) v10(50.15,64.64) v10(50.42,67.02) v10(50.42,66.07) v10(50.42,65.11) v10(50.42,64.16) v10(50.7,64.64) v10(50.97,66.07) v10(50.97,63.21) v10(51.25,66.54) v10(51.25,64.64) v10(51.52,67.02) v10(51.52,63.21) v10(51.8,68.45) v10(51.8,63.69) v10(52.79,70.39) v10(52.79,69.26) v11(49.87,64.16) v11(50.15,64.64) v11(50.42,67.02) v11(50.42,66.07) v11(50.42,65.11) v11(50.42,64.16) v11(50.7,64.64) v11(50.97,66.07) v11(50.97,63.21) v11(51.25,66.54) v11(51.25,64.64) v11(51.52,67.02) v11(51.52,63.21) v11(51.8,68.45) v11(51.8,63.69) v11(52.79,70.39) v11(52.79,69.26) v12(50.21,63.78) v12(50.34,66.57) v12(50.62,65.61) v12(50.82,66.57) v12(50.92,64.29) v12(51.1,65.03) v12(51.18,62.82) v12(51.25,68.2) v12(51.28,63.63) v12(51.41,66.07) v12(51.56,64.24) v12(51.84,69.06) v12(52.4,69.09) v12(52.48,70) v14(67.79,74.83) v14(67.79,74.07) v14(67.79,73.31) v14(67.79,72.54) v14(68.55,74.83) v14(68.55,74.07) v14(68.55,73.31) v14(68.55,72.54) v14(69.31,74.83) v14(69.31,74.07) v14(69.31,73.31) v14(69.31,72.54)
+V_VCC_SENSE: length 28.2
  IN2 w0.254: v12(50.16,63.17) 49.71,62.72 49.71,62.18 49.92,61.97 50.63,61.97 50.88,61.72 50.88,61.26 51.97,60.18 53.9,60.18 54.03,60.3 54.71,60.3 55.56,61.15 56.71,61.15 57.38,61.82 59.24,61.82 59.85,61.22 v4(59.99,61.22)
  IN3 w0.254: v12(50.16,63.17) 50.04,63.17 v1(49.6,62.73) ; v4(59.99,61.22) 60.12,61.34 60.13,61.34 60.36,61.57 61.34,61.57 61.64,61.27 63.29,61.27 64.37,60.19 67.55,60.19 69.87,62.51 69.87,63.5 68.94,64.43 v1(68.94,64.54)
+V_VNN: length 4.8
  IN2 w0.254: v5(52.35,61.49) 52.07,61.77 v12(51.94,61.77) ; v5(54.03,67.36) 54.03,67.12 v12(53.87,66.96) ; v5(54.24,64.54) 54.24,64.79 53.87,65.15 v12(53.84,65.15) ; v5(51.38,65.55) 51.79,65.55 v12(51.83,65.59) ; v12(49.55,60.89) 49.55,61.04 49.3,61.29 v5(49.3,61.39) ; v12(54.68,62.18) 54.44,62.18 v5(54.24,62.38) ; v5(54.14,65.69) 54.14,66.05 v12(54.2,66.12) ; v12(50.42,61.47) 50.1,61.47 v5(50.01,61.38)
  GND3 w0.254: v12(52.85,66.47) 52.85,66.3 v1(52.62,66.07)
  vias: v1(48.77,61.3) v1(49.05,61.78) v1(49.05,60.83) v1(49.32,61.3) v1(49.32,60.35) v1(49.6,61.78) v1(49.6,60.83) v1(49.87,60.35) v1(50.15,61.78) v1(50.42,61.3) v1(50.42,60.35) v1(50.7,61.78) v1(50.97,60.35) v1(51.25,65.59) v1(51.25,61.78) v1(51.25,60.83) v1(51.52,60.35) v1(51.82,65.59) v1(51.8,61.78) v1(52.07,62.26) v1(52.07,61.3) v1(52.07,60.35) v1(52.35,65.59) v1(52.35,62.73) v1(52.35,61.78) v1(52.62,65.11) v1(52.62,64.16) v1(52.62,63.21) v1(52.62,62.26) v1(52.62,60.35) v1(52.9,67.5) v1(52.9,66.54) v1(52.9,65.59) v1(52.9,64.64) v1(52.9,63.69) v1(52.9,61.78) v1(52.9,60.83) v1(53.17,67.02) v1(53.17,60.35) v1(53.45,67.5) v1(53.45,62.73) v1(53.72,67.02) v1(53.72,66.07) v1(53.72,65.11) v1(53.72,64.16) v1(53.72,63.21) v1(53.72,62.26) v1(53.72,60.35) v1(54,67.5) v1(54,66.54) v1(54,65.59) v1(54,64.64) v1(54,63.69) v1(54,61.78) v1(54,60.83) v1(54.27,67.02) v1(54.27,66.07) v1(54.27,65.11) v1(54.27,64.16) v1(54.27,63.21) v1(54.27,62.26) v1(54.27,61.3) v1(54.27,60.35) v1(54.55,66.54) v1(54.55,65.59) v1(54.55,64.64) v1(54.55,63.69) v1(54.55,61.78) v1(54.55,60.83) v1(59.41,55.78) v1(59.41,55.45) v1(60.17,55.78) v10(48.77,61.3) v10(49.05,61.78) v10(49.05,60.83) v10(49.32,61.3) v10(49.32,60.35) v10(49.6,61.78) v10(49.87,60.35) v10(50.15,61.78) v10(50.42,60.35) v10(50.7,61.78) v10(51.25,65.59) v10(51.25,60.83) v10(52.07,62.26) v10(52.07,61.3) v10(52.07,60.35) v10(52.35,65.59) v10(52.35,62.73) v10(52.35,61.78) v10(52.62,62.26) v10(52.62,60.35) v10(52.9,63.69) v10(52.9,61.78) v10(53.17,60.35) v10(53.45,67.5) v10(53.45,62.73) v10(53.72,66.07) v10(53.72,62.26) v10(53.72,60.35) v10(54,67.5) v10(54,66.54) v10(54,65.59) v10(54,64.64) v10(54,63.69) v10(54,61.78) v10(54,60.83) v10(54.27,67.02) v10(54.27,65.11) v10(54.27,63.21) v10(54.27,62.26) v10(54.27,60.35) v10(54.55,66.54) v10(54.55,64.64) v10(54.55,61.78) v10(54.55,60.83) v10(59.41,55.78) v10(59.41,55.45) v10(60.17,55.78) v11(48.77,61.3) v11(49.05,61.78) v11(49.05,60.83) v11(49.32,61.3) v11(49.32,60.35) v11(49.6,61.78) v11(49.87,60.35) v11(50.15,61.78) v11(50.42,60.35) v11(50.7,61.78) v11(51.25,65.59) v11(51.25,60.83) v11(52.07,62.26) v11(52.07,61.3) v11(52.07,60.35) v11(52.35,65.59) v11(52.35,62.73) v11(52.35,61.78) v11(52.62,62.26) v11(52.62,60.35) v11(52.9,63.69) v11(52.9,61.78) v11(53.17,60.35) v11(53.45,67.5) v11(53.45,62.73) v11(53.72,66.07) v11(53.72,62.26) v11(53.72,60.35) v11(54,67.5) v11(54,66.54) v11(54,65.59) v11(54,64.64) v11(54,63.69) v11(54,61.78) v11(54,60.83) v11(54.27,67.02) v11(54.27,65.11) v11(54.27,63.21) v11(54.27,62.26) v11(54.27,60.35) v11(54.55,66.54) v11(54.55,64.64) v11(54.55,61.78) v11(54.55,60.83) v11(59.41,55.78) v11(59.41,55.45) v11(60.17,55.78) v12(52.36,60.95) v12(52.75,63.25) v12(53.15,62.16) v12(53.62,64.11) v12(53.86,63.21) v12(54.2,64.11) v12(54.3,61.32) v12(59.03,55.63) v12(59.79,55.63) v13(57.05,54.76) v14(67.23,54.66) v14(67.23,52.48) v14(67.26,53.9) v14(67.26,53.19) v14(67.94,54.69) v14(67.97,53.98) v14(67.97,53.24) v14(67.97,52.48) v14(68.65,54.69) v14(68.68,53.98) v14(68.68,53.24) v14(68.73,52.48)
+V_VNN_SENSE: length 18.5
  IN2 w0.127: v12(53.31,61.3) 53.75,61.74 55.16,61.74 55.54,62.11 55.54,62.3 55.7,62.46 v4(59.99,62.46)
  IN3 w0.127: v1(68.48,62.38) 68.48,61.99 67.3,60.81 64.63,60.81 63.53,61.9 61.89,61.9 61.57,62.22 60.24,62.22 v4(59.99,62.46)
  IN3 w0.254: v1(53.72,61.3) 53.36,61.3 53.36,61.3 v12(53.31,61.3)
  BOTTOM w0.114: v1(68.48,62.38) 68.83,62.38 68.94,62.5 PR69.1
+V_VSS_SENSE: length 24.3
  IN2 w0.254: v4(59.99,61.8) 59.75,61.8 59.38,62.17 57.24,62.17 56.57,61.49 55.42,61.49 54.57,60.64 53.88,60.64 53.76,60.52 52.11,60.52 51.23,61.4 51.23,61.86 50.75,62.33 50.48,62.33 v12(50.41,62.41)
  IN3 w0.254: v4(59.99,61.8) 60.12,61.93 61.46,61.93 61.77,61.62 63.42,61.62 64.51,60.53 67.41,60.53 69.47,62.58 69.47,63.43 69.11,63.78 v1(68.98,63.78) ; v1(50.15,62.73) 50.15,62.73 50.15,62.67 v12(50.41,62.41)
+VBL_LCM: length 31.6
  IN1 w0.508: v9(67.59,37.54) 67.4,37.73 60.59,37.73 60.47,37.85 57.48,37.85 56.44,36.81 55.47,36.81 54.53,37.75 v2(52.09,37.75) v2(51.33,37.75)
  BOTTOM w0.254: PR87.2 70.63,35.59 70.38,35.84
  BOTTOM w0.508: v9(67.59,37.54) 67.76,37.36 68.48,37.36
  vias: v9(52.24,36.81)
+VCLK_SFR0: length 7.9
  TOP w0.381: v5(54.9,64.54) 54.9,66.46 55.22,66.78 57.68,66.78 57.73,66.73 58.58,66.73 R70.2
  IN2 w0.254: v12(55.14,63.78) 54.9,64.02 v5(54.9,64.54)
  IN3 w0.305: v1(55.65,63.69) 55.24,63.69 v12(55.14,63.78)
+VCLK_SFR1: length 4.8
  TOP w0.381: v5(56.41,63.54) 56.41,63.1 56.71,62.8 58.81,62.8 59.08,63.07 R71.2
  IN2 w0.254: v5(56.41,63.54) 56.41,63.45 56.13,63.17 v12(56.11,63.17)
  IN3 w0.254: v8(56.47,63.31) 56.27,63.31 56.13,63.17 v12(56.11,63.17)
+VHDMI: length 24.3
  TOP w0.508: PC24.1 88.2,66.41 87.82,66.79 87.82,71.95 87.42,72.34 85.44,72.34 F1.3 85.42,73.23 88.08,73.23 v13(90.19,75.34) 90.84,75.98 90.84,76.74 91.08,76.99 D6.2 D5.2
  IN3 w0.305: v11(87.98,65.46) 88.06,65.53 88.06,65.94 v4(88.08,65.97)
  IN4 w0.203: v8(86.48,64.75) 86.61,64.75 86.71,64.85
  IN4 w0.254: v11(87.98,65.46) 87.37,64.85 86.71,64.85
  vias: v2(88.31,66.35) v2(88.57,66.57) v3(88.31,66.35) v3(88.57,66.57) v5(88.31,66.35) v5(88.57,66.57)
+VREF_CA0: length 28.3
  IN3 w0.254: v1(26.95,72.12) 27.5,72.68 29.88,72.68 v8(30.01,72.81)
  IN3 w0.305: v1(35.84,80.25) 35.8,80.25 35.28,80.77 26.31,80.77 25.75,80.21 25.75,72.54 26.17,72.12 v1(26.95,72.12)
  IN4 w0.254: v1(35.84,80.25) 35.84,79.13 v8(34.01,77.31)
  BOTTOM w0.508: R239.2 R238.1 v1(26.95,72.12)
+VREF_CA1: length 28.3
  IN3 w0.254: v8(30.01,56.16) 29.63,56.54 27.75,56.54 v1(27.07,57.22)
  IN3 w0.305: v1(27.07,57.22) 26.71,57.58 24.96,57.58 24.71,57.33 24.71,50.6 26.92,48.39 33.12,48.39 34.03,49.3 v1(34.19,49.3)
  IN4 w0.254: v1(34.19,49.3) 34.51,49.63 v8(34.51,52.16)
  BOTTOM w0.508: v1(27.07,57.22) R241.1 R240.2
+VREF_DQ0: length 91.9
  TOP w0.508: 78.61,57 78.13,56.52 76.07,56.52 75.84,56.29 75.84,49.81 75.12,49.09 69.64,49.09 67.59,51.13 65.55,51.13 64.82,50.4 58.06,50.4 55.44,47.78 49.25,47.78 43.58,53.44 43.58,56.49 39.65,60.43 v13(39.65,64.8) 39.65,66.32 41.04,67.72 R22.2 R19.1 C12.2 38.9,73.77 v5(38.53,73.41) 38.2,73.08 38.2,71.45 v5(33.47,66.73)
  IN2 w0.254: v12(38.4,73.81) 38.53,73.68 v5(38.53,73.41)
  IN2 w0.305: v12(33.68,68.86) 33.47,68.66 v5(33.47,66.73) 33.04,66.73 v4(32.99,66.68)
  IN3 w0.254: v12(33.68,68.86) 33.68,69.09 v8(33.5,69.27) ; v1(33.31,66.38) 33.28,66.38 v4(32.99,66.68) ; v8(38.01,73.81) v12(38.4,73.81)
  IN3 w0.508: v11(82.67,59.59) 82.67,58.4 82.11,57.84 79.5,57.84 79.14,57.48 v4(79.02,57.48)
  IN4 w0.254: v11(82.67,59.59) 83.68,60.59 v8(83.68,60.75)
  vias: v2(78.62,57.68) v2(78.61,57.3) v3(78.62,57.68) v3(78.61,57.3) v5(78.62,57.68) v5(78.61,57.3)
+VREF_DQ1: length 73.5
  TOP w0.508: R23.2 41.04,56.06 41.44,56.46 42.45,56.46 42.85,56.06 v13(42.85,54.89) 42.85,53.11 48.87,47.09 55.9,47.09 58.39,49.58 65.4,49.58 66.14,50.32 67.56,50.32 69.39,48.49 75.36,48.49 76.44,49.56 76.44,50.23 78.64,52.43 78.64,54.55 78.64,54.56 ; v5(33.55,62.79) 33.55,62.31 39.24,56.62 v5(39.24,55.7)
  IN2 w0.305: v12(38.71,55.53) 39.06,55.53 v5(39.24,55.7) ; v12(33.31,60.5) 32.99,60.82 v4(32.99,62.79) v5(33.55,62.79)
  IN3 w0.254: v1(33.3,63.11) 33.3,63.1 v4(32.99,62.79) ; v8(38.34,55.66) 38.57,55.66 v12(38.71,55.53) ; v12(33.31,60.5) 33.31,60.36 v8(33.51,60.16)
  IN3 w0.508: v4(79.07,55.5) 79.07,56.08 80.22,57.24 82.46,57.24 83.28,58.07 v10(83.28,60.17)
  GND3 w0.254: v8(83.68,61.15) 83.68,60.57 v10(83.28,60.17)
  BOTTOM w0.254: U24.H17 v8(38.34,55.66)
  vias: v2(78.64,55.68) v2(78.64,55.25) v3(78.64,55.68) v3(78.64,55.25) v5(78.64,55.68) v5(78.64,55.25)
+VREFB: length 2.2
  IN3 w0.254: v8(84.48,64.75) 84.48,66.73 84.53,66.78 v4(84.53,66.91)
  vias: v2(84.38,66.14) v2(84.55,66.45) v3(84.38,66.14) v3(84.55,66.45) v5(84.38,66.14) v5(84.55,66.45)
+VREFT: length 6.2
  TOP w0.254: PR54.1 PR107.1 PR114.1 82.37,67.55 v5(82.67,67.25)
  IN3 w0.254: v8(84.08,65.15) 84.08,65.35 83.77,65.66 83.77,66.4 83.38,66.78 83.38,67.26 v4(82.83,67.82)
+VRTC: length 36.9
  TOP w0.254: v2(53.87,70.37) 53.18,70.37 R42.2
  TOP w0.381: R111.1 78.16,60.68 76.93,60.68 76.17,61.44 76.17,65.3 76.3,65.43 78.36,65.43 v5(78.76,65.84)
  TOP w0.508: R111.1 R113.2
  IN2 w0.381: v4(78.76,66.65) v5(78.76,65.84)
  IN3 w0.381: v11(78.76,66.07) v4(78.76,66.65)
  IN4 w0.381: v11(78.76,66.07) 68.78,66.07 68.14,66.7 68.14,71.02 65.65,73.52 65.65,74.18 65.38,74.45 v1(64.35,74.45) 64.35,75.12 v9(65.4,76.18)
  BOTTOM w0.381: R324.1 63.8,76.29 65.31,76.29 65.4,76.2 v9(65.4,76.18)
+VRTC_SOC: length 0.9
  IN2 w0.254: v12(53.23,69.01) 53.23,69.33 v5(53.11,69.46)
  IN3 w0.254: v12(53.23,69.01) 53.26,69.01 53.3,68.97 v8(53.64,68.97)
+VSDIO: length 37.5
  IN1 w0.508: v5(82.13,62.76) 81.24,63.65 79.85,63.65 79.37,64.14 76.65,64.14 75.43,62.92 75.43,56.77 73.83,55.17 69.72,55.17 69.34,55.55 66.27,55.55 64.61,53.9 64.61,52.05 63.52,50.95 60.47,50.95 59.84,51.59 58.06,51.59 57.38,52.27 v9(57.38,52.53)
  IN2 w0.254: v5(82.13,62.76) 82.11,62.75 v12(81.66,62.75)
  GND3 w0.254: v8(82.08,62.75) v12(81.66,62.75)
  vias: v13(55.39,52.73)
+VSPI: length 60.8
  TOP w0.254: U5.B2 66.32,47.56 v2(66.1,47.78) ; R83.2 61.41,42.36 R79.2 61.31,42.36 R72.2
  TOP w0.508: v9(60.78,35.54) 61.45,35.54 62.25,36.35 R83.2 64.4,41.52 64.76,41.88 64.76,44.49 v5(64.87,44.6) ; v2(76.74,68.23) 76.74,68.6 75.59,69.75 72.21,69.75 70.99,68.53 69.24,68.53 67.99,67.29 67.99,60.99 65.45,58.45 v2(65.45,52.91)
  IN1 w0.254: v2(76.74,68.23) 75.83,69.14 74.72,69.14 74.18,68.6 v2(74.18,68.23)
  IN1 w0.508: v5(67.59,47.65) 67.46,47.78 v2(66.1,47.78) 66.1,52.26 v2(65.45,52.91)
  IN2 w0.508: v5(67.59,47.65) 64.87,44.93 v5(64.87,44.6)
  BOTTOM w0.508: U30.8 59.97,36.09 59.7,35.83 C276.2 R313.2 60.43,35.2 v9(60.78,35.54)
+VSPI_PROG: length 60.9
  TOP w0.254: U5.C2 66.82,47.56 C80.2 R91.2
  TOP w0.381: v2(62.81,48.39) 66.49,48.39 66.77,48.67 R91.2
  IN1 w0.381: v2(64.13,77.62) 65.53,79.02 68.96,79.02 69.44,78.54 69.44,77.93 66.75,75.24 66.75,69.95 64,67.21 64,66.55 65.38,65.18 67.71,65.18 68.2,64.7 68.2,58.52 67.56,57.89 65.1,57.89 62.4,55.2 58.44,55.2 56.77,53.52 56.77,52.1 60.47,48.39 v2(62.81,48.39)
+VSYS: length 49.6
  TOP w0.254: PR8.1 85.91,66.99 86.41,67.49 86.41,70.33 84.91,71.83 81.99,71.83 81.28,71.12 v5(81.28,70.16)
  TOP w0.381: PR19.2 90.19,56.82 89.91,56.54 88.26,56.54 v5(87.65,57.15) ; R672.2 v5(86.22,43.84)
  TOP w0.508: v14(108.48,46.86) 108.48,46.86 108.48,42.83 108.84,42.47 115.11,42.47 115.47,42.83 PR27.1 PR28.2
  IN2 w0.254: v5(86.22,43.84) 87.17,43.84 87.68,44.35 87.68,45.96 v4(87.93,46.21)
  IN2 w0.381: v4(81.28,70.64) v5(81.28,70.16)
  IN3 w0.381: v4(87.93,46.21) 87.7,45.98 v11(87.3,45.98)
  GND3 w0.254: v1(80.95,64.82) 81.16,64.61 ; v8(82.48,63.15) v8(82.08,63.15)
  GND3 w0.381: 81.16,64.61 81.42,64.35 v8(82.08,64.35) ; v8(82.08,63.15) 81.91,63.15 81.84,63.22 81.43,63.22 81.12,62.92 v12(81.12,62.76)
  IN4 w0.203: v8(82.08,61.95) 81.73,61.95 81.43,61.65 ; 83.21,65.62 v8(83.28,65.55)
  IN4 w0.254: v1(78.41,61.88) 78.64,61.65 81.43,61.65 ; v8(83.28,60.75) 81.45,58.92 v1(81.45,58.6) ; 83.21,65.62 83.21,65.94 82.8,66.35 82.8,66.63 v1(82.39,67.03)
  IN4 w0.381: v11(87.3,45.98) 84.58,45.98 84.22,45.62 83.61,45.62 82.87,46.37 v1(82.87,46.38)
  BOTTOM w0.114: PU5.M1 v8(82.08,64.35)
  vias: v1(73.45,49.56) v1(73.68,49.28) v1(73.91,49.56) v1(76.2,62.46) v1(76.2,61.8) v1(76.2,57.38) v1(76.2,56.72) v1(76.48,58.32) v1(76.7,59.03) v1(76.96,68.2) v1(77.24,67.34) v1(77.26,69.32) v1(77.26,68.99) v1(77.26,68.63) v1(77.29,68.23) v1(77.26,67.69) v1(77.26,67.01) v1(77.29,62.46) v1(77.26,61.77) v1(77.26,59.03) v1(77.29,58.37) v1(77.29,57.38) v1(77.26,56.72) v1(80.08,55.78) v1(80.08,54.89) v1(80.24,71.05) v1(80.18,70.44) v1(80.74,71.12) v1(80.69,55.81) v1(80.67,54.92) v1(80.82,70.36) v1(81.73,71.3) v1(81.71,70.89) v1(81.73,55.78) v1(81.73,54.89) v1(82.04,71.07) v1(82.19,55.78) v1(82.19,54.87) v1(82.37,71.05) v1(85.82,57.66) v1(85.82,57.2) v1(86.05,68.48) v1(86.05,68.12) v1(86.38,57.66) v1(86.38,57.2) v1(86.94,71.45) v1(86.89,70.61) v1(87.02,57.66) v1(87.02,57.2) v1(87.25,70.61) v1(87.27,71.45) v1(87.58,57.66) v1(87.58,57.2) v1(87.78,69.09) v1(87.78,68.63) v1(88.34,69.09) v1(88.34,68.63) v1(89.84,65.69) v1(89.84,65.15) v1(89.94,61.39) v1(90.19,61.16) v1(90.32,65.69) v1(90.32,65.15) v1(91.11,65.69) v1(91.11,65.13) v1(91.56,65.69) v1(91.56,65.13) v1(93.52,70.64) v1(93.49,69.83) v1(93.52,69.14) v1(94.05,70.64) v1(94.05,69.83) v1(94.05,69.14) v2(90.04,65.89) v2(90.37,65.86) v2(149.76,73.05) v2(150.14,73.05) v2(153.31,75.44) v2(153.91,75.44) v3(90.04,65.89) v3(90.37,65.86) v4(75.41,52.96) v4(75.41,52.38) v4(76.73,68.61) v4(76.76,69.24) v4(76.76,67.82) v4(76.76,67.21) v4(76.76,62.43) v4(76.76,61.83) v4(76.91,58.62) v4(76.93,57.89) v4(76.96,57.08) v4(76.98,56.31) v4(80.34,55.37) v4(80.54,70.72) v4(80.9,55.37) v4(81.28,71.2) v4(81.43,55.37) v4(81.96,55.37) v4(86.1,57.43) v4(86.69,68.38) v4(86.71,57.43) v4(87.04,71.02) v4(87.3,57.43) v4(87.6,70.99) v4(88.06,68.86) v4(88.62,68.86) v4(90.08,65.42) v4(90.52,60.89) v4(90.7,65.43) v4(91.34,65.41) v4(93.77,70.26) v4(93.77,69.5) v5(90.04,65.89) v5(90.37,65.86) v9(20.29,27.41) v9(20.29,26.77) v9(20.29,26.14) v9(20.93,27.41) v9(20.93,26.77) v9(20.93,26.14) v10(73.45,49.56) v10(73.68,49.28) v10(73.91,49.56) v10(76.2,62.46) v10(76.2,61.8) v10(76.2,57.38) v10(76.2,56.72) v10(76.48,58.32) v10(76.7,59.03) v10(76.96,68.2) v10(77.24,67.34) v10(77.26,69.32) v10(77.26,68.99) v10(77.26,68.63) v10(77.29,68.23) v10(77.26,67.69) v10(77.26,67.01) v10(77.29,62.46) v10(77.26,61.77) v10(77.26,59.03) v10(77.29,58.37) v10(77.29,57.38) v10(77.26,56.72) v10(80.08,55.78) v10(80.08,54.89) v10(80.24,71.05) v10(80.18,70.44) v10(80.74,71.12) v10(80.69,55.81) v10(80.67,54.92) v10(80.82,70.36) v10(81.73,71.3) v10(81.71,70.89) v10(81.73,55.78) v10(81.73,54.89) v10(82.04,71.07) v10(82.19,55.78) v10(82.19,54.87) v10(82.37,71.05) v10(85.82,57.66) v10(85.82,57.2) v10(86.05,68.48) v10(86.05,68.12) v10(86.38,57.66) v10(86.38,57.2) v10(86.94,71.45) v10(86.89,70.61) v10(87.02,57.66) v10(87.02,57.2) v10(87.25,70.61) v10(87.27,71.45) v10(87.58,57.66) v10(87.58,57.2) v10(87.78,69.09) v10(87.78,68.63) v10(88.34,69.09) v10(88.34,68.63) v10(89.84,65.69) v10(89.84,65.15) v10(89.94,61.39) v10(90.19,61.16) v10(90.32,65.69) v10(90.32,65.15) v10(91.11,65.69) v10(91.11,65.13) v10(91.56,65.69) v10(91.56,65.13) v10(93.52,70.64) v10(93.49,69.83) v10(93.52,69.14) v10(94.05,70.64) v10(94.05,69.83) v10(94.05,69.14) v11(73.45,49.56) v11(73.68,49.28) v11(73.91,49.56) v11(76.2,62.46) v11(76.2,61.8) v11(76.2,57.38) v11(76.2,56.72) v11(76.48,58.32) v11(76.7,59.03) v11(76.96,68.2) v11(77.24,67.34) v11(77.26,69.32) v11(77.26,68.99) v11(77.26,68.63) v11(77.29,68.23) v11(77.26,67.69) v11(77.26,67.01) v11(77.29,62.46) v11(77.26,61.77) v11(77.26,59.03) v11(77.29,58.37) v11(77.29,57.38) v11(77.26,56.72) v11(80.08,55.78) v11(80.08,54.89) v11(80.24,71.05) v11(80.18,70.44) v11(80.74,71.12) v11(80.69,55.81) v11(80.67,54.92) v11(80.82,70.36) v11(81.73,71.3) v11(81.71,70.89) v11(81.73,55.78) v11(81.73,54.89) v11(82.04,71.07) v11(82.19,55.78) v11(82.19,54.87) v11(82.37,71.05) v11(85.82,57.66) v11(85.82,57.2) v11(86.05,68.48) v11(86.05,68.12) v11(86.38,57.66) v11(86.38,57.2) v11(86.94,71.45) v11(86.89,70.61) v11(87.02,57.66) v11(87.02,57.2) v11(87.25,70.61) v11(87.27,71.45) v11(87.58,57.66) v11(87.58,57.2) v11(87.78,69.09) v11(87.78,68.63) v11(88.34,69.09) v11(88.34,68.63) v11(89.84,65.69) v11(89.84,65.15) v11(89.94,61.39) v11(90.19,61.16) v11(90.32,65.69) v11(90.32,65.15) v11(91.11,65.69) v11(91.11,65.13) v11(91.56,65.69) v11(91.56,65.13) v11(93.52,70.64) v11(93.49,69.83) v11(93.52,69.14) v11(94.05,70.64) v11(94.05,69.83) v11(94.05,69.14) v13(149.78,73.61) v14(107.9,77.07) v14(107.92,76.35) v14(108.61,77.09) v14(108.66,76.38) v14(109.17,47.02) v14(109.88,50.06) v14(109.88,49.3) v14(109.88,48.54) v14(109.88,47.78) v14(109.88,47.02) v14(110.59,50.06) v14(110.59,49.3) v14(110.59,48.54) v14(110.59,47.78) v14(110.59,47.02)
+VSYS_S: length 3.3
  TOP w0.114: v13(86.26,63.78) 86.51,63.53 v5(87.36,63.53)
  IN2 w0.305: v12(87.3,64.11) 87.36,64.05 v5(87.36,63.53)
  GND3 w0.254: v12(87.3,64.11) 86.94,64.11 86.38,63.55 v8(86.08,63.55)
+VSYS_V3.3A:
  vias: v1(110,77.24) v1(110.26,76.99) v1(110.26,74.19) v1(110.51,73.81) v1(110.55,69.62)
+VUSBPHY: length 2.7
  TOP w0.114: v13(86.51,62.51) 86.64,62.64 PC22.1
  IN2 w0.305: v12(87.53,62.89) 87.53,62.59 v5(87.42,62.49)
  GND3 w0.254: v12(87.53,62.89) 87.53,62.92 87.09,63.35 86.68,63.35 v8(86.48,63.15)
+XDP_VSPI_PROG: length 2.9
  TOP w0.203: 62.13,76.1 62.05,76.02 61.57,76.02 61.42,75.88 CN1.39
  TOP w0.381: R85.1 62.66,76.63 62.13,76.1
AC_PRESENT: length 36.4
  IN3 w0.064: v11(54.51,74.96) 54.51,76.47 54.8,76.76 54.8,77.01 55.34,77.55 56.75,77.55 57.67,78.46 64.71,78.46 66.11,77.06 66.11,76.56 66.39,76.28 66.7,76.28 67.56,77.14 76.6,77.14 77.33,76.4 78.84,76.4 v11(79.14,76.1)
  IN4 w0.06: v11(54.51,74.96) 54.96,74.5 54.96,73.64 54.63,73.31 54.63,71.98 53.97,71.32 53.97,71 v8(53.92,70.95)
  IN4 w0.127: v11(79.14,76.1) 79.78,76.1 80.36,76.68 81.15,76.68 v1(81.45,76.99)
AC_PRESENT_R: length 25.2
  IN3 w0.064: v8(83.28,63.15) 83.07,62.94 82.77,62.94 82.5,63.21 81.36,63.21 79.28,65.3 78.39,65.3 78.06,64.97 77.38,64.97 77.21,65.14 77.21,65.88 77.85,66.51 77.85,69.95 80.1,72.21 82.54,72.21 82.79,72.46 82.79,77.28 81.99,78.08 v1(81.99,78.36)
  BOTTOM w0.114: PR85.1 81.68,78.03 v1(81.99,78.36)
ACCEL_C1: length 3.7
  BOTTOM w0.114: C360.1 165.95,82.88 U35.6
ACCEL_INT1: length 109.8
  IN2 w0.064: v9(166.37,82) 165.25,80.88 165.25,78.74 161.07,74.56 149.41,74.56 144.13,69.28 130.46,69.28 127.12,65.94 127.12,58.32 126.26,57.46 124.61,57.46 122.42,55.27 122.42,42.17 120.65,40.39 104.72,40.39 103.08,42.02 102.85,42.02 102.03,42.85 99.94,42.85 98.14,41.04 95.79,41.04 94.89,41.94 94.89,44.42 v5(94.89,44.42)
  BOTTOM w0.114: v9(166.37,82) 166.45,82.08 U35.5
ACCEL_INT2: length 109.6
  IN2 w0.064: v9(166.27,80.42) 166.27,79.5 161.14,74.38 149.44,74.38 144.19,69.13 130.53,69.13 127.3,65.9 127.3,58.25 126.33,57.28 124.68,57.28 122.58,55.17 122.58,42.07 120.72,40.21 104.64,40.21 103.04,41.81 102.84,41.81 101.96,42.69 100.01,42.69 98.2,40.89 95.72,40.89 94.38,42.23 94.38,44.42 v5(94.39,44.42)
  BOTTOM w0.114: U35.4 166.52,81.28 166.27,81.02 v9(166.27,80.42)
ACCEL_L: length 2.5
  TOP w0.127: U10.11 98.41,43.3 99.04,43.93 R154.2 R156.1
ACCEL_M: length 3.8
  TOP w0.114: U10.12 98.01,44.4 99.56,45.95 R153.1 R155.2
ACCEL_N: length 2.7
  TOP w0.114: R147.1 R146.2
  TOP w0.127: R146.2 97.39,45.59 U10.13
ACCEL_SETN: length 7.7
  BOTTOM w0.114: U35.13 174.92,78.88 175.03,78.77 175.03,75.55 174.6,75.12 C359.1
ACCEL_SETP: length 9.4
  BOTTOM w0.114: U35.12 175.01,79.68 175.23,79.45 175.23,75.29 174.23,74.28 C359.2
ACPI_INT#: length 106.4
  TOP w0.114: v5(117.01,56.52) 117.1,56.6 U12.A3 ; R166.2 111.73,57.68 v5(112.24,58.19)
  IN2 w0.064: v4(75.97,54.38) 75.64,54.71 75.64,55.05 75.33,55.36 75.33,61.16 75.48,61.31 76.1,61.93 76.1,70 73.3,72.8 71.78,72.8 71.42,73.15 70.76,73.15 70.56,73.36 70.56,75.29 69.85,76 67.48,76 67.05,75.57 65.96,75.57 65.78,75.74 65.78,76.61 v4(65.76,76.63) ; v5(117.01,56.52) 116.46,55.96 115.95,55.96 115.59,56.31 115.59,57.05 116.05,57.51 116.05,58.5 115.24,59.31 113.81,59.31 112.7,58.19 v5(112.24,58.19) 112.21,58.19 112.01,57.99 111.1,57.99 110.66,58.42 109.04,58.42 107.31,60.16 104.49,60.16 103.65,60.99 102.18,60.99 101.95,60.76 100.81,60.76 98.85,58.8 93.21,58.8 86.15,51.74 v4(86.08,51.74)
  IN3 w0.064: v11(55.37,75.72) 55.39,75.74 55.39,75.78 55.8,76.19 56.11,76.19 56.51,76.59 56.51,77.09 57.73,78.31 64.65,78.31 65.76,77.2 v4(65.76,76.63) ; v4(86.08,51.74) 86,51.74 84.42,50.16 82.3,50.16 81.17,49.03 79.9,49.03 76.88,52.06 76.88,53.53 76.23,54.17 76.05,54.17 75.97,54.26 v4(75.97,54.38)
  IN4 w0.06: 54.91,75.21 54.88,75.18 54.88,74.75 55.14,74.49 55.14,73.41 54.81,73.08 54.81,72.21 54.76,72.16 54.76,71.51 54.21,70.95 v8(54.21,70.67)
  IN4 w0.064: 54.91,75.21 55.37,75.67 v11(55.37,75.72)
ADCDAT: length 5.7
  BOTTOM w0.114: U34.32 116.9,69.02 116.26,68.39 115.46,68.39 C323.2 114.98,67.1 114.98,66.16 R368.2
ALS_INT#: length 111
  TOP w0.114: U1.3 4.73,43.75 v5(4.51,43.97) 2.68,43.97 R3.2 ; U10.28 90.88,42.3 90.73,42.14 v5(90.7,42.14)
  IN2 w0.064: v5(90.7,42.14) 90.73,42.11 90.73,40.26 91.61,39.37 91.61,37.59 91.39,37.36 91.39,37.11 91.11,36.83 90.85,36.83 87.75,33.73 44.85,33.73 v4(44.35,33.22) ; v4(24.51,30.05) 23.92,30.63 23.92,37.54 18.54,42.93 14.93,42.93 14.22,43.64 12.04,43.64 11.71,43.97 8.38,43.97 8.3,44.05 4.58,44.05 v5(4.51,43.97)
  IN3 w0.064: v4(44.35,33.22) 43.91,32.79 43.18,32.79 42.62,33.35 41.87,33.35 40.18,31.66 35.7,31.66 34.22,33.15 27.73,33.15 24.63,30.05 v4(24.51,30.05)
ANT1_PAD1: length 2
  BOTTOM w0.114: R211.1 15.14,38.98 C142.2 15.14,39.06 R210.2
ANT1_R: length 1.3
  BOTTOM w0.114: U19.4 15.18,36.17 15.14,36.21 R211.2
ANT2_PAD2: length 2
  BOTTOM w0.114: R205.2 14.5,6.72 C140.2 14.5,6.8 R209.1
ANT2_R: length 1.6
  BOTTOM w0.114: R209.2 14.64,8.71 U20.4
ANT_0: length 5.1
  BOTTOM w0.102: 162.79,71.82 U36.N10
  BOTTOM w0.292: C373.2 L28.1 162.79,71.82
ANT_1: length 4.9
  BOTTOM w0.102: U36.N1 arc(153.74,71.6) 153.52,71.37
  BOTTOM w0.292: C374.2 L29.1 arc(152.14,69.31) 152.53,70.14 arc(152.86,70.66) 153.26,71.12 153.52,71.37
AUDIO_SCL: length 3
  BOTTOM w0.114: R358.1 113.76,69.42 113.76,70.81 113.94,71 U34.38
AUDIO_SDA: length 2.6
  BOTTOM w0.114: U34.39 113.99,71.4 113.53,70.93 113.53,69.83 113.42,69.72 R357.1
BAT-:
  vias: v1(110.05,45.39) v1(110.05,45.01) v1(110.05,44.65) v1(110.05,44.27) v1(110.05,43.92) v1(110.05,43.56) v1(110.05,43.21) v1(110.05,42.85) v1(110.05,42.5) v1(110.64,45.39) v1(110.64,45.01) v1(110.64,44.65) v1(110.64,44.27) v1(110.64,43.92) v1(110.64,43.56) v1(110.64,43.21) v1(110.64,42.85) v1(110.64,42.5) v1(113.41,41.81) v1(113.41,41.43) v1(113.38,39.78) v1(113.38,39.42) v1(113.74,41.81) v1(113.74,41.43) v1(113.71,39.78) v1(113.71,39.42) v1(114.07,41.81) v1(114.07,41.43) v1(114.07,39.78) v1(114.07,39.42) v1(114.4,41.81) v1(114.4,41.43) v1(114.4,39.78) v1(114.4,39.42) v1(114.75,41.81) v1(114.75,41.43) v1(114.75,39.78) v1(114.75,39.42) v1(115.08,41.81) v1(115.08,41.43) v1(115.08,39.78) v1(115.08,39.42)
BAT_CLK: length 24.8
  TOP w0.114: v5(114.83,56.34) C117.1 114.02,55.89 R171.1 ; PR31.2 119.92,52.25 118.72,52.25 118.51,52.45 115.57,52.45 v5(115.34,52.22)
  IN2 w0.064: v4(114.55,55.83) 114.55,56.06 v5(114.83,56.34) 114.86,56.36 114.86,58.09 v5(114.6,58.34) 114.6,58.83 114.57,58.85 114.25,58.85 113,57.61 110.41,57.61 109.87,58.14 108.96,58.14 107.51,59.59 106.5,59.59 v4(106.37,59.46) ; v5(115.34,52.22) 115.34,52.58 v4(115.52,52.76)
  IN3 w0.064: v4(106.37,59.46) 106.24,59.59 105.99,59.59 v1(105.97,59.62) ; v4(114.55,55.83) 114.55,55.58 114.88,55.25 114.88,53.39 v4(115.52,52.76)
  BOTTOM w0.114: v1(105.97,59.62) 105.57,60.01 PR117.2
BAT_DATA: length 27.7
  TOP w0.114: v5(115.08,52.48) 115.29,52.68 118.61,52.68 118.82,52.48 120.72,52.48 121.18,52.02 PR33.2 ; v5(114.34,58.59) 114.59,58.84 U12.C8 ; R167.1 111.26,56.36 C111.1
  IN2 w0.064: v5(111.68,56.69) 111.81,56.57 114.2,56.57 v4(114.35,56.41) 114.68,56.75 114.68,57.91 114.34,58.25 v5(114.34,58.59) 114.24,58.59 113.08,57.43 110.33,57.43 109.8,57.96 108.89,57.96 107.62,59.23 v4(107.24,59.23) ; v4(114.8,52.15) 115.08,52.43 v5(115.08,52.48)
  IN3 w0.064: v4(107.24,59.23) 106.93,59.54 v1(106.93,59.59) ; v4(114.35,56.41) 114.2,56.26 114.2,55.68 114.7,55.17 114.7,52.25 v4(114.8,52.15)
  BOTTOM w0.114: v1(106.93,59.59) 106.93,59.67 106.59,60.01 PR118.2
BAT_ID: length 76.9
  TOP w0.114: v5(112.54,54.13) 112.54,53.98 112.75,53.77 118.31,53.77 118.64,54.1 118.64,57.3 U12.A1 ; v5(83.68,67.21) PR7.1 83.68,65.43 PC11.1
  IN1 w0.064: v5(112.54,54.13) 111.83,54.13 110.46,55.5 110.46,56.67 110.64,56.85 110.64,58.45 110.44,58.65 110.44,61.8 v5(109.75,62.49)
  IN2 w0.064: v4(115.8,43.54) 117.52,43.54 119.43,45.44 119.43,46.37 119.01,46.79 117.99,46.79 114.02,50.76 114.02,52.98 112.87,54.13 v5(112.54,54.13)
  IN2 w0.127: v5(109.75,62.49) 109.72,62.51 109.42,62.51 107.9,64.03 96.52,64.03 94.92,65.64 94.92,68.33 94.13,69.11 92.82,69.11 91.85,70.08 88.11,70.08 87.19,69.17 87.19,68.23 86.48,67.51 83.98,67.51 v5(83.68,67.21) 83.68,67.1 v12(83.94,66.83)
  IN3 w0.064: v1(114.45,42.86) 115.12,42.86 v4(115.8,43.54)
  IN3 w0.127: v11(83.82,67.26) 83.82,67.21 83.94,67.08 v12(83.94,66.83)
  IN4 w0.06: 83.82,66.27 83.82,66.08 83.88,66.02 83.88,64.95 v8(84.08,64.75)
  IN4 w0.064: 83.82,66.63 83.82,66.27
  IN4 w0.127: v11(83.82,67.26) 83.82,66.63
BAT_SCL: length 4.7
  TOP w0.114: PU1.A3 119.53,47.63 119.83,47.63 120.47,48.26 120.47,49.51 TP22.1 120.29,50.7 PR31.1
BAT_SDA: length 4.8
  TOP w0.114: PU1.B3 119.53,47.4 119.93,47.4 120.7,48.17 120.7,49.84 TP25.1 121.18,50.32 PR33.1
BATLED0#: length 135.3
  TOP w0.114: U12.F9 113.29,60.34 112.42,61.22 v5(112.42,62.97) ; v9(8.12,72.04) R6.1
  IN2 w0.064: v5(112.42,62.97) 112.32,62.87 110.36,62.87 109.88,63.35 109.37,63.35 107.97,64.75 105.33,64.75 104.82,65.25 99.18,65.25 98.96,65.48 98.96,66.1 96.24,68.82 96.24,69.38 93.99,71.63 91.75,71.63 91.67,71.54 86.01,71.54 v4(85.26,70.79)
  IN3 w0.064: v4(85.26,70.79) 85.61,71.14 85.85,71.14 86.84,72.13 86.84,75.06 85.57,76.33 85.57,77.3 85.7,77.43 85.7,78.81 83.36,81.15 69.64,81.15 67.14,83.66 62.57,83.66 60.83,85.4 59,85.4 57.12,83.52 53.57,83.52 52.42,82.37 24.74,82.37 22.7,80.34 11.76,80.34 10.51,79.1 10.51,75.77 7.88,73.14 7.88,72.28 v9(8.12,72.04)
BATLED1#: length 134.5
  TOP w0.114: v9(7.67,71.27) 7.54,71.15 R4.1 ; U12.H9 113.66,61.34 113.08,61.93 v5(113.08,62.97)
  IN2 w0.064: v5(113.08,62.97) 112.75,62.64 110.31,62.64 109.81,63.13 109.36,63.13 107.95,64.54 105.2,64.54 104.68,65.06 99.16,65.06 98.73,65.5 98.73,66.11 96.01,68.83 96.01,69.26 93.81,71.45 91.79,71.45 91.73,71.39 86.27,71.39 85.82,70.94 v4(85.82,70.79)
  IN3 w0.064: v4(85.82,70.79) 85.82,70.9 86.99,72.07 86.99,75.12 85.87,76.24 85.87,76.73 85.72,76.89 85.72,77.24 85.86,77.37 85.86,78.91 83.46,81.31 69.71,81.31 67.21,83.81 62.63,83.81 60.89,85.55 58.94,85.55 57.08,83.69 53.44,83.69 52.27,82.53 24.64,82.53 22.63,80.52 11.68,80.52 10.33,79.17 10.33,75.9 7.68,73.24 7.68,72.06 7.67,72.05 v9(7.67,71.27)
BATT1_THERM: length 4.4
  BOTTOM w0.114: PU7.12 106.72,53.64 106.96,53.87 PR128.2 107.79,53.87 108.2,53.47 108.84,53.47 108.99,53.62 108.99,54.3 PR141.1
BATT2_THERM: length 3.8
  BOTTOM w0.114: PU7.11 107.06,54.14 PR127.2 107.69,54.76 108.15,55.22 109.03,55.22 PR140.1
BATT_THERM: length 26.9
  TOP w0.114: U12.D1 118.12,59.34 v5(118.46,59.01)
  IN2 w0.064: v5(118.46,59.01) 118.46,55.7 118.01,55.25 118.01,53.04 118.65,52.39 118.65,50.99 120.21,49.43 120.21,42.75 119.15,41.68 115.76,41.68 114.45,42.99 114.45,45.07 v5(114.62,45.24)
BATT_THERM_S: length 11.3
  IN2 w0.064: v5(121.69,42.44) 120.14,42.44 119.2,41.51 115.72,41.51 114.02,43.21 v4(114.02,44.86) 114.02,44.88 113.77,45.13 v5(113.77,45.24)
  IN3 w0.064: v1(114.45,44.86) 114.02,44.86 v4(114.02,44.86)
BCLK: length 4.9
  BOTTOM w0.114: U34.30 117.7,69.1 116.35,67.76 C328.2 116.84,67.02 116.84,66.23 R374.2
BOARD_ID_0: length 12.8
  TOP w0.114: v5(91.54,66.63) 91.54,68.86 91.61,68.94 92.45,68.94 92.88,69.37 R123.2 R136.1
  IN2 w0.064: v4(91.46,66.17) 91.54,66.24 v5(91.54,66.63)
  IN3 w0.06: 87.45,64.44 86.92,64.44 86.02,63.55 v8(85.68,63.55)
  IN3 w0.064: 87.45,64.44 89.23,64.44 89.58,64.8 89.58,65.79 89.76,65.97 90.57,65.97 90.78,66.17 v4(91.46,66.17)
BOARD_ID_1: length 15
  TOP w0.114: v5(90.98,66.17) 90.98,66.3 91.23,66.55 91.23,70.46 91.46,70.69 92.66,70.69 92.9,70.93 R121.2 R134.1
  IN2 w0.064: v5(90.98,66.17) 90.5,66.17 v4(90.34,66.32)
  IN3 w0.06: 87.45,64.62 86.86,64.62 85.99,63.75 85.48,63.75 v8(85.28,63.55)
  IN3 w0.064: v4(90.34,66.32) 90.22,66.19 89.76,66.19 89.43,65.86 89.43,64.87 89.18,64.62 87.45,64.62
BOARD_ID_2: length 13.1
  TOP w0.114: R135.1 R122.2 92.9,69.99 92.76,69.85 91.82,69.85 v5(91.51,69.55)
  IN2 w0.064: v4(91.03,69.55) v5(91.51,69.55)
  IN3 w0.06: v8(84.88,63.55) 84.88,63.57 85.34,64.03 85.34,64.39 85.5,64.55 86.13,64.55 86.99,65.41 86.99,66.14
  IN3 w0.064: v4(91.03,69.55) 89.79,68.3 89,68.3 88.64,67.95 88,67.95 86.99,66.94 86.99,66.14
BOARD_ID_3: length 29.1
  TOP w0.114: R126.2 R139.1
  IN2 w0.064: v4(94.38,66.37) v5(94.05,66.7)
  IN3 w0.06: 84.61,60.17 84.61,61.52 84.25,61.88 84.25,62.13 84.46,62.35 v8(84.48,62.35)
  IN3 w0.064: 84.61,60.17 84.61,58.74 84.88,58.47 84.88,56.52 85.34,56.06 85.34,55.09 85.65,54.79 88.41,54.79 90.09,56.47 92.17,56.47 95.96,60.25 95.96,62.95 94.71,64.2 94.71,66.04 v4(94.38,66.37)
BODYSAR_N: length 148.2
  TOP w0.114: v5(116.81,62.26) 116.81,62.97 117.75,63.91 R177.1 ; U12.E1 118.26,59.84 v5(118.46,60.05)
  IN2 w0.064: v4(117.85,42.17) 117.85,43.03 120.01,45.19 120.01,49.38 118.44,50.95 118.44,52.39 117.67,53.15 117.67,56.88 117.35,57.21 117.35,59.95 117.46,60.06 117.46,60.16 117.65,60.35 118.16,60.35 v5(118.46,60.05) 118.46,60.56 118.41,60.61 117.57,60.61 117.45,60.73 117.45,61.62 v5(116.81,62.26)
  IN3 w0.064: v1(31.9,10.95) 31.8,10.95 25.65,17.1 25.65,29.06 28.8,32.21 33.88,32.21 35.33,30.76 40.58,30.76 42.18,32.36 44.62,32.36 45.01,32.74 45.01,33.48 45.18,33.66 57.05,33.66 57.33,33.37 102.89,33.37 106.32,36.81 106.32,38.1 107.39,39.17 114.86,39.17 v4(117.85,42.17)
BODYSAR_S: length 126.5
  TOP w0.114: v5(116.38,63.48) 116.86,63.96 R175.1 ; v5(113.1,59.39) 113.26,59.23 113.71,59.23 114.1,58.85 U12.C9
  IN2 w0.064: v5(113.1,59.39) 113.79,60.07 114.86,60.07 115.67,60.89 115.67,61.09 115.08,61.67 115.08,62.87 115.31,63.1 116.02,63.1 116.38,63.45 v5(116.38,63.48) 116.99,62.87 118.69,62.87 119.12,62.43 119.12,61.72 120.24,60.61 120.24,59.11 119.81,58.68 119.81,55.69 120.19,55.31 120.19,52.02 120.65,51.56 v4(121.18,51.56)
  IN3 w0.06: v8(49.96,57.94) 50.19,57.71 50.19,56.87 51.08,55.98 51.08,54.59 ; 51.13,52.91 51.13,53.42 51.08,53.47
  IN3 w0.064: 51.08,54.59 51.08,53.47 ; v4(121.18,51.56) 121.26,51.49 121.26,47.88 113.52,40.15 107.04,40.15 105.34,38.45 105.34,37.66 103.09,35.41 102.31,35.41 101.97,35.08 81.14,35.08 80.85,34.8 72.28,34.8 66.89,40.19 64.44,40.19 63.64,41 54.74,41 54.11,41.63 50,41.63 48.69,42.95 48.69,47.52 50.92,49.76 50.92,51.84 51.13,52.05 51.13,52.91
BOOT0: length 1.4
  TOP w0.114: U10.44 95.39,36.27 R143.1
BQ27520_A1: length 4.9
  TOP w0.114: PR23.2 114.99,47.87 115.12,47.99 PC28.1 115.98,47.99 116.02,47.95 PC31.1 TP16.1
  TOP w0.127: PC31.1 116.66,47.76 PU1.A1
BQ27520_B1: length 4.9
  TOP w0.114: PR24.2 115,46.93 115.12,47.06 PC29.2 115.94,47.06 115.98,47.1 PC31.2 TP17.1
  TOP w0.127: PU1.B1 117.31,47.26 117.15,47.1 PC31.2
BQ27520_D2: length 6.5
  TOP w0.114: TP14.1 113.95,44.01 PR26.1 115.08,44.01 ; PR27.2 115.98,44.53 117.29,44.53 117.55,44.78 117.55,45.67 v5(117.7,45.82)
  TOP w0.127: PR27.2 115.08,44.01
  IN2 w0.064: v5(117.7,45.82) 117.7,45.95 118.01,46.26 v5(118.89,46.26)
BQ27520_D3: length 3.9
  TOP w0.114: PC35.1 PR35.2
  TOP w0.127: PR35.2 121.52,46.8 TP28.1 120.15,46.26 PU1.D3
BQ27520_E1: length 3.1
  TOP w0.127: PR28.1 PC32.1 117.24,44.07 TP18.1 117.98,45.35 PU1.E1
BQ27520_E3: length 7.5
  TOP w0.114: PC34.1 PR32.2 119.91,44.5 120.09,44.68 120.09,45.06 TP26.1 121.2,45.68 121.2,44.67 PR36.2
  TOP w0.127: PU1.E3 119.73,45.42 119.73,44.72 PC34.1
BRTC_EXTPAD: length 5.3
  IN4 w0.06: v1(59.33,75.06) 59.33,74.46 58.89,74.02 58.49,74.02 57.16,72.68 57.16,71.47 57.3,71.33 57.3,70.97 v8(57.32,70.95)
BT_DEV_EN: length 141.5
  IN3 w0.06: v8(55.9,58.22) 55.9,57.72 56.78,56.84 60,56.84 60.66,56.17 60.98,56.17
  IN3 w0.064: v1(155.76,80.82) 156.01,80.57 156.01,79.81 155.86,79.67 153.45,79.67 152.47,80.65 150.53,80.65 149.36,79.48 147.82,79.48 139.23,70.89 131.99,70.89 130.94,69.84 128.06,69.84 125.5,67.28 125.5,66.24 121.83,62.57 117.74,62.57 116.36,63.94 116.36,68.35 115.74,68.98 114.48,68.98 113.54,69.92 112.25,69.92 111.55,69.22 111.55,68.68 109.69,66.82 109.69,62.75 108.19,61.25 106.94,61.25 105.46,59.77 105.46,56.9 106.14,56.21 106.14,53.75 105.51,53.11 101.62,53.11 99.31,50.8 99.31,49.56 99.3,49.54 99.3,49.19 98.97,48.86 94.72,48.86 94.07,48.21 92.54,48.21 92.28,48.46 v1(91.84,48.46) 91.75,48.55 89.43,48.55 89.2,48.33 83.29,48.33 82.95,47.99 78.05,47.99 75.97,50.07 75.97,53.24 75.83,53.37 74.27,53.37 74.11,53.21 74.11,52.65 73.4,51.94 70.84,51.94 70.27,51.37 69.97,51.37 69.54,51.8 66.97,51.8 65.42,53.36 65.42,53.79 63.58,55.63 62.61,55.63 62.07,56.17 60.98,56.17
BT_DEV_WAKE: length 132
  IN3 w0.06: 60.98,55.83 60.62,55.83 59.86,56.59 56.69,56.59 55.42,57.85 55.42,58.3 v8(55.62,58.5)
  IN3 w0.064: v1(148.36,79.12) 147.73,79.12 139.31,70.7 132.07,70.7 131.02,69.65 128.14,69.65 125.69,67.2 125.69,66.16 121.91,62.38 117.53,62.38 116.17,63.75 116.17,68.28 115.66,68.78 114.4,68.78 113.46,69.72 112.33,69.72 111.74,69.14 111.74,68.6 109.88,66.74 109.88,62.67 108.26,61.04 107.01,61.04 105.66,59.69 105.66,57.15 106.35,56.47 106.35,53.62 105.64,52.91 101.75,52.91 99.56,50.73 99.56,47.98 98.73,47.14 92.56,47.14 91.92,47.78 90.47,47.78 90.12,48.13 83.37,48.13 83.02,47.79 78,47.79 77.99,47.77 74.48,47.77 73.17,49.07 73.17,49.7 71.76,51.11 71.05,51.11 70.67,50.73 70.34,50.73 70.22,50.85 68.3,50.85 68.12,51.02 67.27,51.02 65.08,53.22 65.08,53.64 63.44,55.28 62.47,55.28 61.93,55.83 60.98,55.83
  BOTTOM w0.114: R395.1 148.19,79.29 v1(148.36,79.12)
BT_FM_PCM_I2S_CLK_R: length 2.7
  IN1 w0.064: v9(158.01,78.61) 158.39,78.23 159.49,78.23 v2(159.75,78.49)
  BOTTOM w0.114: U36.F5 157.56,78.16 v9(158.01,78.61)
BT_FM_PCM_I2S_IN_R: length 7.5
  IN3 w0.064: v1(157.56,77.22) 157.5,77.22 156.99,77.73 156.7,77.73 156.41,78.01 156.41,78.33 155.62,79.12 152.38,79.12 151.72,79.78 v1(151.28,79.78)
BT_FM_PCM_I2S_OUT_R: length 6.9
  IN3 w0.064: v1(152.04,80.16) 152,80.13 152,79.75 152.45,79.3 155.7,79.3 156.66,78.34 v1(156.66,78.12)
  BOTTOM w0.114: R398.1 151.56,80.77 152.04,80.29 v1(152.04,80.16)
BT_FM_PCM_I2S_SYNC_R: length 12.1
  IN3 w0.064: v1(156.66,77.22) 157.12,77.22 157.38,76.96 157.76,76.96 157.88,77.09 157.88,77.27 157.5,77.65 157.5,77.75 155.77,79.48 153.34,79.48 152.4,80.42 150.64,80.42 149.98,79.76 v1(149.98,79.45)
  BOTTOM w0.114: v1(149.98,79.45) 150.44,79 R401.1
BT_HOST_WAKE: length 137.1
  IN2 w0.064: v4(87.68,76.89) 87.68,76.58 86.61,75.52 85.95,75.52 85.42,76.05 82.2,76.05 81.49,76.76 v4(81.35,76.76)
  IN3 w0.06: v8(53.36,69.82) 53.36,69.93 53.38,69.95 53.38,71.78
  IN3 w0.064: v4(81.35,76.76) 81.33,76.73 80.09,76.73 79.58,77.24 77.68,77.24 76.35,78.58 66.02,78.58 65.15,79.45 57.2,79.45 56.51,78.77 54.76,78.77 54.1,78.11 54.1,77.78 v1(54,77.67) 53.95,77.62 53.95,77.12 53.46,76.63 53.46,72.39 53.38,72.31 53.38,71.78 ; v4(87.68,76.89) 95.3,76.89 96.54,78.13 102.57,78.13 108.38,72.32 109.04,72.32 109.27,72.09 109.27,70.6 109.67,70.19 110.43,70.19 111.29,71.06 114.72,71.06 116.74,69.03 116.74,64.1 117.88,62.96 121.68,62.96 125.12,66.4 125.12,67.44 127.9,70.22 130.77,70.22 131.82,71.27 139.07,71.27 147.66,79.86 149.18,79.86 150.35,81.03 152.8,81.03 153.34,80.49 155.06,80.49 155.63,81.07 157.57,81.07 157.86,80.77 158.37,80.77 v9(158.82,81.23)
  BOTTOM w0.114: U36.B7 159.26,81.62 159.21,81.62 v9(158.82,81.23)
CAM1_CSI_A_D0N: length 7.8
  IN3 w0.07: v1(14.78,58.18) 14.78,61.01 15.44,61.67 15.44,63.48 15.17,63.75 15.01,63.75 v1(14.91,63.86)
  BOTTOM w0.076: v1(14.91,63.86) 14.95,63.9 CN6.2
CAM1_CSI_A_D0P: length 7.8
  IN3 w0.07: v1(14.23,58.18) 14.41,58.18 14.6,58.37 14.6,61.08 15.27,61.74 15.27,63.41 15.1,63.58 14.98,63.58 14.91,63.5 v1(14.91,63.45)
  BOTTOM w0.076: CN6.20 15.25,63.5 15.15,63.6 15.06,63.6 v1(14.91,63.45)
CAM1_CSI_A_D1N: length 7.9
  IN3 w0.07: v1(16.89,64.01) 16.89,64 17.25,64 17.43,63.83 17.43,61.93 16.98,61.49 16.98,58.26 v1(17.06,58.18)
  BOTTOM w0.076: v1(16.89,64.01) 16.75,64.15 CN6.5
CAM1_CSI_A_D1P: length 7.8
  IN3 w0.07: v1(16.86,63.6) 17.09,63.83 17.18,63.83 17.26,63.75 17.26,62 16.81,61.56 16.81,58.27 16.73,58.18 v1(16.51,58.18)
  BOTTOM w0.076: CN6.17 17.05,63.55 17,63.6 v1(16.86,63.6)
CAM1_CSI_CLKN: length 7.7
  IN3 w0.07: v1(15.92,63.78) 15.92,63.86 15.85,63.93 15.64,63.93 15.42,64.16 15.42,64.78 15.27,64.92 14.88,64.92 14.82,64.86 14.82,64.35 14.63,64.16 14.12,64.16 13.61,64.67 13.36,64.67 13.23,64.54 13.23,63.68 13.01,63.46 12.41,63.46 v1(12.33,63.38)
  BOTTOM w0.076: CN6.19 15.85,63.71 v1(15.92,63.78)
CAM1_CSI_CLKP: length 7.7
  IN3 w0.07: v1(12.33,63.93) 12.33,63.74 12.44,63.63 12.94,63.63 13.06,63.75 13.06,64.61 13.29,64.84 13.68,64.84 14.19,64.33 14.56,64.33 14.65,64.42 14.65,64.93 14.81,65.1 15.34,65.1 15.59,64.85 15.59,64.23 15.71,64.1 15.81,64.1 v1(15.92,64.21)
  BOTTOM w0.076: v1(15.92,64.21) 16.15,64.44 CN6.4
CAM1_PWDN: length 72.7
  IN3 w0.064: v11(50.26,73.64) 50.26,73.89 49.98,74.17 49.98,75.34 48.64,76.68 48.64,79.45 46.65,81.44 25.58,81.44 24.15,80.01 24.15,50.34 24.87,49.63 24.87,49.13 24.41,48.67 23.52,48.67 v1(21.87,47.02)
  IN4 w0.06: v11(50.26,73.64) 50.19,73.56 50.03,73.56 49.11,72.64 v8(49.11,71.24)
  BOTTOM w0.114: R224.1 21.27,45.85 20.87,46.25 Q16.1 21.71,46.82 R229.2
CAM1_PWDN_C: length 8.6
  IN3 w0.064: v1(17.35,65.34) 17.53,65.15 19.05,65.15 19.2,65 v1(19.2,58.36)
CAM1_PWDN_R: length 18.2
  IN3 w0.064: v1(21.4,49.05) 19.58,50.87 19.58,57.14 v1(19.2,57.52)
  BOTTOM w0.114: R229.1 21.87,48.58 v1(21.4,49.05) 21.4,48.96 20.47,48.03 Q16.3 20.05,47.97 19.26,47.18 R214.1 17.61,47.18 16.28,45.85 Q14.5
CAM2_CSI_CLKN: length 8
  IN3 w0.07: v1(8.42,47.95) 8.33,48.04 8.13,48.04 8.03,47.94 8.03,47.38 8.22,47.19 11.18,47.19 11.31,47.32 11.31,47.75 11.55,47.99 12.29,47.99 v1(12.48,48.18)
  BOTTOM w0.076: v1(8.42,47.95) 8.55,47.82 CN5.14
CAM2_CSI_CLKP: length 7.6
  IN3 w0.07: v1(8.42,48.29) 8.33,48.21 8.06,48.21 7.86,48.01 7.86,47.31 8.15,47.02 11.25,47.02 11.48,47.25 11.48,47.68 11.62,47.82 12.29,47.82 v1(12.48,47.63)
  BOTTOM w0.076: v1(8.42,48.29) 8.25,48.46 CN5.8
CAM2_CSI_D0N: length 8.3
  IN3 w0.07: v1(9.3,48.29) 9.41,48.19 9.78,48.19 9.84,48.12 10.22,48.12 10.84,48.74 14.22,48.74 15.05,47.91 15.45,47.91 15.53,47.99 15.53,48.1 15.45,48.18 v1(15.15,48.18)
  BOTTOM w0.076: CN5.10 9.45,48.44 v1(9.3,48.29)
