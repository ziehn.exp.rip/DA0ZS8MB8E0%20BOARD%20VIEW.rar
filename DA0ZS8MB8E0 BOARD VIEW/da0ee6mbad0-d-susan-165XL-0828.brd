# Allegro board da0ee6mbad0-d-susan-165XL-0828.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
AVDD_ADO: length 12.5
  IN3 w0.508: v1(119.91,80.54) 119.78,80.67 v1(119.02,80.67) 118.26,79.91 116.99,79.91 116.2,79.12 116.2,77.93 117.32,76.81 119.99,76.81 120.67,76.13 120.67,74.45
  vias: v1(120.6,74.2) v1(120.95,74.19) v2(122.22,74.4) v2(122.5,74.17) v3(120.57,73.79) v3(120.9,73.79) v4(121.36,73.81) v5(120.57,73.79) v5(120.9,73.79) v10(120.6,74.2) v10(120.95,74.19) v11(120.6,74.2) v11(120.95,74.19)
GND: length 131.2
  TOP w0.114: SW4.2 65.27,86.65 66.14,85.78 v3(66.24,85.78) ; T3.1 68.58,80.67 ; CN3.10 v3(74.7,83.79) ; CN3.4 v3(73.5,83.79)
  TOP w0.203: v3(111.81,47.73) 111.81,47.6 111.79,47.59 U37.1 ; CN3.13 v3(75.3,79.77) ; CN3.7 v3(74.1,79.77)
  TOP w0.254: C35.2 51.15,60.58 v3(51.36,60.78) ; Q11.1 v3(125.1,62.22) ; v3(70.15,86.26) 69.77,86.65 SW4.1 ; R50.1 v3(54.89,80.47) ; v3(51.83,62.55) 51.53,62.55 C36.2 ; Q4.2 68.58,79.76 R94.2 T3.1 ; 2.05,66.65 1.66,66.26 SW1.1 ; v3(1.85,62.28) 1.66,62.1 SW1.2 ; C56.2 55.32,71.47 v3(55.32,71.48) ; C115.2 v3(113.31,65.36) ; Q9.1 v3(85.76,48.78) ; C38.2 51.47,64.13 v3(51.91,63.68) ; v3(51.84,66.04) 51.82,66.03 C37.2 ; PC16.2 v5(85.26,63.86) ; v3(38.62,11.31) Q1.1 ; PC22.2 v5(88.72,62.64) ; C119.2 115.97,65.33 ; C75.1 v3(62.07,68.66)
  TOP w0.305: v3(98.01,41.8) 98.56,41.8 98.92,42.15 C103.2
  TOP w0.381: v9(6.98,44.95) U1.1
  TOP w0.508: v9(11.1,43.46) 10.35,43.46 ; v9(14.88,83.06) 15.66,82.28 U2.3 ; v9(14.68,85.32) U2.1
  IN2 w0.381: v5(88.72,62.64) 88.67,62.59 88.01,62.59 v12(87.98,62.61)
  IN3 w0.064: v11(18.85,62.46) 18.85,59.11 18.31,58.57 v10(18.31,58.35)
  IN3 w0.254: v8(83.68,64.35) 83.99,64.35 84.05,64.29 v12(84.07,64.29)
  GND3 w0.06: 42.97,71.53 42.87,71.53 42.77,71.63 ; 43.61,70.69 43.61,70.82 43.46,70.97 ; 46,58.85 45.93,58.85 45.8,58.99 45.79,58.99 45.74,59.03 ; 51.61,68.2 51.61,68.33 51.43,68.51 ; 84.28,62.55 84.67,62.55 84.68,62.54 ; 45.62,69.32 45.44,69.5 ; 44.8,59.84 44.52,60.12 44.52,60.15 ; 84.28,63.83 84.28,63.82 84.28,63.63 84.28,63.63 84.28,63.44 84.37,63.35 85.11,63.35 85.11,63.35 ; 47.72,61.62 47.85,61.49 47.9,61.49 ; 45.77,57.94 45.77,57.99 46.25,58.47 46.25,58.52 ; 47.17,69.57 47.39,69.8 ; 44.47,58.95 44.35,58.83 44.29,58.83 ; 47.09,58.75 47.16,58.75 47.21,58.7 47.22,58.7 47.33,58.59 47.33,58.58 47.39,58.52 ; 83.87,62.92 83.88,62.92 83.88,63.63 83.89,63.65 83.89,63.76 ; 46.45,58.78 46.71,58.78 ; 47.85,68.73 48.1,68.73 ; 48.74,68.66 48.74,68.33 ; 45.73,69.27 45.98,69.52 ; 46.35,69.32 46.21,69.17 46.2,69.17 46.08,69.06 46.08,69.05 46.05,69.01 ; 85.48,63.29 85.48,63.63 85.59,63.75 85.86,63.75 86,63.88 86,63.91 ; 86.26,62.64 86.35,62.55 86.73,62.55 86.76,62.51 ; 85.12,62.95 85.11,62.95 84.28,62.95 ; 44.73,68.43 45.11,68.43 ; 47.14,58.22 47.13,58.22 46.86,58.49 46.86,58.52 ; 51.81,60.1 52.24,60.1 52.35,60.2 52.35,60.5 ; 49.32,61.98 49.32,61.72 49.58,61.47 ; 47.11,58.8 47.14,58.8 47.21,58.87 47.22,58.87 47.33,58.99 47.33,59 47.39,59.06 ; 46.28,58.95 46.25,58.98 46.25,59.11 46.21,59.15 46.2,59.15 46.08,59.27 46.08,59.27 46.05,59.31 ; 47.39,69.28 47.18,69.5 ; 46.25,69.78 46.25,69.85 46.2,69.9 46.2,69.9 46.08,70.02 46.08,70.02 45.92,70.18 45.92,70.19 45.8,70.3 45.8,70.3 45.74,70.36 ; 49.88,61.98 49.88,61.62
  GND3 w0.066: 52.35,60.2 52.45,60.1 52.78,60.1 52.9,60.22 ; 52.9,60.22 53.03,60.1 53.31,60.1 ; 52.9,60.22 52.9,60.48
  GND3 w0.076: 51.86,63.98 51.66,63.91 51.47,63.91 51.3,63.98 51.1,63.98
  IN4 w0.254: v1(175.12,81.28) 175.1,81.25 v1(175.1,80.48) 175.1,75.34 175.1,75.34
  BOTTOM w0.089: U29.AV58 43.4,62.18 v8(43.35,62.23)
  BOTTOM w0.114: v8(44.02,69.54) 43.99,69.51 43.99,69.02 U29.M58 44.02,68.9 U29.P58 ; v8(43.35,66.14) 43.36,66.14 U29.AB58 ; v8(44.59,64.45) U29.AH56 ; PU5.R6 v8(83.68,65.55) ; v1(8.85,49.08) v1(8.85,48.2)
  BOTTOM w0.203: v8(32.37,57.29) 32.01,57.65 U24.M5 ; U20.9 v1(17.01,11.46) ; v1(93.65,45.01) 93.63,45.02 U31.1 ; U24.M4 31.73,57.43 v8(31.73,57.42) ; U19.9 v1(16.53,33.81) ; U29.AN59 U29.AM58 ; v8(59.05,58.47) 59.3,58.22 U29.BM2 ; v8(38.01,57.66) U24.N17 ; v1(31.11,19.79) 31.39,20.07 v1(31.39,20.24) v1(31.39,20.64) v1(31.39,21.04) v1(30.99,21.04) ; U18.3 v1(15.77,47.91) U18.6 ; U16.6 v1(13.1,47.91) U16.3 ; v8(43.66,64.73) v8(43.95,64.45)
  BOTTOM w0.254: v8(29.68,58.33) 30.01,58.66 U24.P1 ; CN7.71 v9(20.05,9.55) ; U24.G16 v1(38.01,54.66) ; v8(87.28,65.55) v8(87.28,65.95) PU5.R14 ; U24.U6 32.75,60.4 v8(32.75,60.42) ; U23.M8 35.36,73.95 v8(35.19,73.95) ; v8(38.26,73.06) 38.25,73.06 U23.U9 ; U29.BC59 43.95,61.05 U29.BB58 ; U23.U16 v8(38.01,70.31) ; v9(16.2,7.77) 16.02,7.6 16.02,7.06 15.72,6.76 C140.1 ; U24.U9 33.77,60.4 v8(33.77,60.42) ; U24.U12 v8(36.01,60.16) ; v8(38.26,53.91) 38.01,53.66 U24.D17 ; U24.T17 v8(38.01,59.16) ; v8(37.01,73.81) v8(37.01,74.31) v8(37.51,74.31) U23.U6 ; U27.2 38,19.56 v1(37.69,19.86) ; U29.A27 52.23,72.44 51.44,73.22 v1(51.44,73.94) ; U24.H15 37.02,55.66 v8(37.26,55.42) ; PU8.3 v1(105.18,71.02) 104.31,71.02 ; U29.A11 56.75,72.66 56.93,72.84 v1(56.93,73.53) C273.2 56.93,74.44 ; U29.AN59 43.95,63.31 U29.AP58 ; v1(36.34,21.36) 36.18,21.53 Y2.2 ; 14.25,34.95 14.25,34.96 U19.2 ; U24.M8 v8(33.51,57.3) ; v8(37.74,60.4) 37.51,60.17 U24.U16 ; v8(38.26,56.4) 38.02,56.16 U24.J17 ; U24.T7 v8(33.01,59.16) ; CN13.13 141.75,75.21 142,75.46 v1(142.77,75.46) ; U23.U4 38.01,75.81 v8(38.26,75.55) ; v8(43.66,64.73) 43.95,65.01 U29.AF58 ; v8(35.51,53.66) v8(35.51,54.16) ; C318.2 116.73,80.68 116.46,80.95 v1(115.26,80.95) ; 88.21,39.13 v1(87.48,39.13) ; U23.U12 v8(38.01,71.31)
  BOTTOM w0.279: 88.28,37.63 v1(87.48,37.63) ; 88.24,38.13 v1(87.48,38.13) ; 88.21,38.63 v1(87.48,38.63)
  BOTTOM w0.305: v9(25.04,7.01) 25.05,7.02 CN7.51 ; CN7.5 36.55,9.25 v9(36.98,9.68) 37.05,9.61 CN7.3 ; CN7.57 v9(23.55,7.01) ; v1(15.64,9.22) 15.64,9.23 U20.2 ; U35.11 v1(175.1,80.48) ; CN7.27 31.05,7.18 v9(30.81,6.94) ; 166.44,86.23 166.46,86.25 170.42,86.25 170.71,85.96 U35.7 ; CN7.73 19.55,9.07 19.33,9.3 v9(19.33,9.55) ; 26.55,6.67 CN7.45 ; CN7.11 35.05,7.54 34.92,7.42 34.57,7.42 34.44,7.54 v9(34.44,7.9) ; U35.10 v1(175.12,81.28) ; v9(29.55,7.06) CN7.33 ; CN7.39 v9(28.05,7.01)
  BOTTOM w0.381: v9(8.51,72.83) Q13.2 ; C142.1 v1(17.04,39.02)
  BOTTOM w0.508: C358.1 v9(171.64,74.07)
  vias: v1(1.93,68.86) v1(1.85,61.98) v1(1.98,72.65) v1(2.13,44.06) v1(2.46,43.03) v1(2.94,63.04) v1(2.99,68.12) v1(2.99,43.8) v1(3.15,73.51) v1(3.15,71.73) v1(3.1,66.85) v1(3.2,69.37) v1(3.2,64.59) v1(3.35,48.8) v1(3.37,76.02) v1(3.71,49.86) v1(3.78,61.42) v1(4.05,49.08) v1(4.21,43) v1(4.8,49.86) v1(4.92,45.37) v1(5.25,49.08) v1(5.66,63.1) v1(5.89,75.19) v1(5.86,49.86) v1(5.85,49.08) v1(6.17,48.13) v1(6.58,69.22) v1(6.73,67.59) v1(6.85,65.56) v1(7.11,49.86) v1(7.21,77.29) v1(7.41,62.33) v1(7.46,72.44) v1(7.46,43.31) v1(7.64,70.46) v1(7.69,74.25) v1(7.69,73.33) v1(7.95,46.03) v1(8.4,69.22) v1(8.45,49.86) v1(8.68,62.79) v1(8.89,72.04) v1(8.91,66.22) v1(9.04,76.81) v1(9.06,78.18) v1(9.14,65.48) v1(9.22,83.01) v1(9.27,79.33) v1(9.32,70.51) v1(9.55,63.04) v1(9.5,49.86) v1(9.6,75.44) v1(9.78,81.94) v1(9.75,46.03) v1(10,80.42) v1(9.98,73.59) v1(10,71.1) v1(10.11,65.99) v1(10.18,67.84) v1(10.31,43.08) v1(10.46,49.86) v1(10.56,68.86) v1(10.74,67.62) v1(10.75,48.8) v1(10.94,79.27) v1(10.94,75.24) v1(10.87,66.52) v1(10.97,72.65) v1(11.1,73.26) v1(11.2,49.86) v1(11.43,62.51) v1(11.68,74.8) v1(11.71,64.15) v1(11.71,63.15) v1(11.76,80.14) v1(12.14,60.12) v1(12.14,59.11) v1(12.14,58.09) v1(12.14,57.08) v1(12.14,56.06) v1(12.14,55.04) v1(12.14,54.03) v1(12.14,53.01) v1(12.14,52) v1(12.14,50.98) v1(12.14,49.96) v1(12.32,81.13) v1(12.57,82.09) v1(12.63,43.46) v1(13.03,62.61) v1(13.1,57.43) v1(13.41,59.29) v1(13.41,55.45) v1(13.69,81.23) v1(13.65,65.06) v1(13.71,50.52) v1(13.84,83.62) v1(13.84,61.11) v1(13.87,49.23) v1(14,57.56) v1(14.12,63.1) v1(14.4,44.35) v1(14.47,42.95) v1(14.55,63.65) v1(14.65,62.46) v1(14.88,82.36) v1(15,57.56) v1(15.21,59.08) v1(15.21,49.2) v1(15.26,51.68) v1(15.29,41.99) v1(15.41,54.38) v1(15.43,15.27) v1(15.43,14.38) v1(15.54,29.82) v1(15.55,65.34) v1(15.63,44.99) v1(15.64,22.99) v1(15.77,83.26) v1(15.9,61.62) v1(16.02,82.46) v1(16.13,27.1) v1(16.29,57.56) v1(16.25,18.54) v1(16.45,62.46) v1(16.58,63.83) v1(16.56,49.51) v1(16.81,59.29) v1(16.94,60.2) v1(16.93,42.95) v1(17.07,41.05) v1(17.21,16.16) v1(17.21,15.27) v1(17.21,14.38) v1(17.29,57.56) v1(17.4,58.85) v1(17.42,43.28) v1(17.4,37.62) v1(17.42,11.93) v1(17.6,61.52) v1(17.6,8.05) v1(17.7,26.54) v1(17.7,18.78) v1(17.75,20.73) v1(17.93,40.74) v1(17.93,32.28) v1(18.21,23.17) v1(18.28,57.53) v1(18.28,53.98) v1(18.36,84.18) v1(18.4,82.58) v1(18.44,59.68) v1(18.55,65.34) v1(18.69,49.89) v1(18.77,46.56) v1(18.95,47.63) v1(18.89,38.71) v1(18.92,11.36) v1(19,28.58) v1(19.15,65.34) v1(19.38,56.06) v1(19.73,18.26) v1(19.81,51.59) v1(19.86,54.56) v1(20.04,82.32) v1(20.09,46.76) v1(20.22,61.57) v1(20.28,41.92) v1(20.35,65.34) v1(20.39,60.4) v1(20.43,45.75) v1(20.5,23.93) v1(20.47,11.84) v1(20.6,19.29) v1(20.6,10.95) v1(20.6,10.06) v1(20.76,36.86) v1(20.76,35.97) v1(20.76,35.08) v1(20.76,34.19) v1(20.76,33.3) v1(20.93,59.46) v1(20.89,58.32) v1(20.89,57.43) v1(21.02,81.43) v1(21.05,65.06) v1(21.49,53.62) v1(21.49,41.9) v1(21.52,12.6) v1(21.61,83.47) v1(21.71,35.84) v1(21.87,61.75) v1(22.04,45.39) v1(22.02,31.01) v1(22.16,52.86) v1(22.2,48.64) v1(22.25,46.23) v1(22.27,65.28) v1(22.27,38.94) v1(22.5,18.91) v1(22.58,53.98) v1(22.68,54.74) v1(23.01,40.67) v1(23.14,42.52) v1(23.26,83.54) v1(23.34,31.45) v1(23.52,44.15) v1(23.64,66.7) v1(23.64,65.43) v1(23.64,32.69) v1(23.77,82.58) v1(23.77,81.81) v1(23.77,71.53) v1(23.77,70.26) v1(23.77,69.11) v1(23.77,67.97) v1(23.9,80.16) v1(23.9,79.15) v1(23.9,77.88) v1(23.9,76.61) v1(23.9,75.34) v1(23.9,74.07) v1(23.9,72.8) v1(24.1,35.49) v1(24.38,37.62) v1(24.36,29.54) v1(24.41,29.14) v1(24.61,80.6) v1(24.63,79.35) v1(24.63,75.19) v1(24.63,70.21) v1(24.61,68.07) v1(24.61,64.95) v1(24.66,76.48) v1(24.66,72.85) v1(24.74,39.9) v1(24.79,47.02) v1(24.79,14.89) v1(24.79,10.82) v1(25.04,82.58) v1(24.99,24.18) v1(25.09,42.85) v1(25.09,28.47) v1(25.07,19.53) v1(25.17,77.46) v1(25.17,74.66) v1(25.17,72.84) v1(25.17,70.93) v1(25.24,34.19) v1(25.3,57.98) v1(25.3,56.2) v1(25.3,53.53) v1(25.3,50.88) v1(25.42,25.63) v1(25.5,32.46) v1(25.78,17.1) v1(26.06,80.25) v1(26.06,75.72) v1(26.14,74.83) v1(26.06,72.96) v1(26.14,69.37) v1(26.14,68.48) v1(26.14,67.59) v1(26.06,47.02) v1(26.18,56.38) v1(26.21,53.62) v1(26.18,49.09) v1(26.31,82.58) v1(26.27,61.75) v1(26.27,60.86) v1(26.27,59.97) v1(26.27,54.51) v1(26.57,43.46) v1(26.57,42.44) v1(26.57,41.43) v1(26.57,40.54) v1(26.57,39.52) v1(26.57,38.51) v1(26.57,37.36) v1(26.57,36.35) v1(26.57,35.33) v1(26.57,34.19) v1(26.57,32.92) v1(26.57,31.78) v1(26.57,30.63) v1(26.57,29.62) v1(26.57,25.81) v1(26.57,24.79) v1(26.57,23.65) v1(26.57,22.63) v1(26.57,21.49) v1(26.69,28.47) v1(26.95,72.96) v1(26.95,71.19) v1(27.07,58.15) v1(27.07,56.38) v1(27.2,44.1) v1(27.33,47.02) v1(27.45,82.58) v1(27.71,28.35) v1(27.81,30.01) v1(27.94,36.43) v1(28.05,21.36) v1(28.05,20.47) v1(28.05,19.58) v1(28.05,18.7) v1(28.06,40.57) v1(28.06,39.04) v1(28.14,37.8) v1(28.06,29.71) v1(28.34,44.1) v1(28.34,13.62) v1(28.39,41.53) v1(28.6,47.02) v1(28.72,82.58) v1(28.68,29.74) v1(28.72,26.19) v1(28.85,42.47) v1(28.85,28.35) v1(29.36,10.95) v1(29.51,37.34) v1(29.61,80.25) v1(29.74,49.09) v1(29.74,44.1) v1(29.74,23.14) v1(29.74,13.62) v1(29.87,47.02) v1(29.87,26.19) v1(29.87,15.23) v1(29.99,82.58) v1(29.99,65.43) v1(29.99,64.01) v1(29.99,24.66) v1(30.12,10.82) v1(30.4,42.27) v1(30.38,28.35) v1(30.63,18.29) v1(30.63,17.83) v1(30.63,17.27) v1(30.73,39.09) v1(30.68,22.71) v1(30.68,19.23) v1(30.65,18.77) v1(30.76,19.74) v1(30.76,15.23) v1(30.88,24.66) v1(30.91,16.87) v1(30.88,10.95) v1(31.01,44.1) v1(31.01,26.19) v1(31.01,18.37) v1(31.01,17.86) v1(31.04,17.3) v1(31.14,47.02) v1(31.11,19.28) v1(31.11,18.85) v1(31.14,13.62) v1(31.21,83.82) v1(31.26,82.58) v1(31.29,42.09) v1(31.42,29.73) v1(31.44,17.27) v1(31.39,16.87) v1(31.39,15.01) v1(31.52,28.35) v1(31.65,65.4) v1(31.65,64.07) v1(31.85,37.21) v1(31.77,24.66) v1(31.79,21.84) v1(31.79,20.64) v1(31.82,16.87) v1(31.9,40.49) v1(31.95,29.66) v1(31.9,17.27) v1(31.9,14.89) v1(32.15,44.1) v1(32.15,26.19) v1(32.18,16.89) v1(32.33,36.23) v1(32.33,35.23) v1(32.31,17.27) v1(32.28,14.76) v1(32.36,83.82) v1(32.41,47.02) v1(32.53,82.58) v1(32.46,19.76) v1(32.46,19.31) v1(32.48,18.82) v1(32.51,13.62) v1(32.66,24.79) v1(32.66,16.87) v1(32.83,35.73) v1(32.83,34.23) v1(32.76,32.06) v1(32.79,28.35) v1(32.81,17.27) v1(32.79,15.01) v1(32.92,19.81) v1(32.94,19.33) v1(32.94,18.82) v1(33.09,81.59) v1(33.09,42.19) v1(33.14,16.89) v1(33.17,81.09) v1(33.22,17.27) v1(33.3,65.4) v1(33.3,64.07) v1(33.3,44.1) v1(33.3,26.19) v1(33.37,19.53) v1(33.37,18.82) v1(33.42,14.89) v1(33.68,83.67) v1(33.68,47.02) v1(33.73,42.88) v1(33.74,17.21) v1(33.8,82.58) v1(33.78,19.25) v1(33.8,18.82) v1(33.8,13.62) v1(33.93,23.05) v1(34.01,81.61) v1(34.06,81.09) v1(34.06,28.35) v1(34.06,14.89) v1(34.19,48.54) v1(34.31,44.1) v1(34.33,37.23) v1(34.31,26.19) v1(34.26,18.82) v1(34.34,17.02) v1(34.34,16.64) v1(34.4,24.92) v1(34.41,19.25) v1(34.55,17.47) v1(34.67,18.75) v1(34.72,17.02) v1(34.69,14.89) v1(34.79,42.17) v1(34.77,16.64) v1(34.95,83.64) v1(34.9,81.61) v1(34.95,65.4) v1(34.95,64.07) v1(34.95,47.02) v1(35.07,82.58) v1(35.07,48.54) v1(35.07,36.17) v1(35.1,19.15) v1(35.14,18.14) v1(35.14,17.37) v1(35.07,13.62) v1(35.15,29.64) v1(35.15,18.72) v1(35.33,38.23) v1(35.33,28.35) v1(35.46,44.1) v1(35.46,26.19) v1(35.46,16.64) v1(35.61,18.9) v1(35.56,17.04) v1(35.68,31.29) v1(35.75,20.85) v1(35.75,19.97) v1(35.68,18.44) v1(35.76,81.61) v1(35.84,81.09) v1(35.81,42.88) v1(35.83,35.73) v1(35.94,17.04) v1(35.96,48.54) v1(36.06,83.75) v1(36.06,16.69) v1(36.22,47.02) v1(36.17,18.44) v1(36.34,82.58) v1(36.34,13.62) v1(36.42,17.04) v1(36.47,44.1) v1(36.55,28.35) v1(36.5,18.75) v1(36.6,65.4) v1(36.6,64.07) v1(36.7,81.59) v1(36.73,81.09) v1(36.73,26.19) v1(36.67,18.42) v1(36.7,16.69) v1(36.83,36.73) v1(36.78,19.86) v1(36.8,17.04) v1(36.85,48.54) v1(36.98,24.79) v1(36.98,19.31) v1(36.98,18.77) v1(37.11,42.14) v1(37.06,30.71) v1(37.18,32.01) v1(37.21,16.77) v1(37.33,29.67) v1(37.28,25.17) v1(37.28,23.14) v1(37.28,22.68) v1(37.26,22.23) v1(37.28,21.01) v1(37.28,20.5) v1(37.26,19.99) v1(37.41,83.67) v1(37.49,82.58) v1(37.49,47.02) v1(37.49,44.1) v1(37.49,18.93) v1(37.59,81.59) v1(37.61,81.09) v1(37.61,15.23) v1(37.61,13.62) v1(37.74,48.54) v1(37.74,28.35) v1(37.69,25.27) v1(37.69,24.84) v1(37.69,24.41) v1(37.69,23.98) v1(37.69,23.57) v1(37.69,23.09) v1(37.69,22.63) v1(37.69,22.2) v1(37.69,21.77) v1(37.69,21.31) v1(37.69,20.85) v1(37.66,20.4) v1(37.72,16.77) v1(37.83,35.23) v1(37.87,26.19) v1(38.12,65.4) v1(38.12,64.07) v1(38.1,42.19) v1(38.1,25.25) v1(38.1,24.87) v1(38.53,81.61) v1(38.5,81.09) v1(38.5,44.1) v1(38.53,25.25) v1(38.53,24.87) v1(38.5,15.23) v1(38.63,48.54) v1(38.63,31.17) v1(38.66,83.57) v1(38.66,32.21) v1(38.76,82.58) v1(38.76,47.02) v1(38.88,28.35) v1(38.93,17.45) v1(38.88,16.99) v1(38.91,16.56) v1(38.88,13.62) v1(39.01,26.19) v1(38.96,25.3) v1(38.96,24.87) v1(39.01,15.57) v1(39.06,17.88) v1(39.06,16.11) v1(39.24,21.62) v1(39.24,21.11) v1(39.24,20.65) v1(39.24,20.19) v1(39.24,19.74) v1(39.16,19.36) v1(39.16,18.9) v1(39.16,18.37) v1(39.32,30.3) v1(39.31,23.49) v1(39.27,22.99) v1(39.3,22.25) v1(39.34,17.48) v1(39.34,17.04) v1(39.32,16.49) v1(39.44,31.68) v1(39.52,25.2) v1(39.52,24.79) v1(39.49,15.7) v1(39.65,42.14) v1(39.65,21.06) v1(39.62,19) v1(39.65,18.39) v1(39.6,17.91) v1(39.7,38.41) v1(39.67,21.62) v1(39.67,20.47) v1(39.7,19.81) v1(39.85,40.01) v1(39.93,25.12) v1(39.93,24.79) v1(39.9,24.03) v1(39.9,23.39) v1(40.03,82.58) v1(40.03,47.02) v1(40.03,13.62) v1(40.13,83.67) v1(40.18,33.89) v1(40.2,29.74) v1(40.15,28.35) v1(40.15,26.19) v1(40.28,23.06) v1(40.36,35.46) v1(40.38,25.1) v1(40.41,24.74) v1(40.36,3.58) v1(40.48,22.76) v1(40.64,23.06) v1(40.74,24.94) v1(40.79,54.54) v1(40.76,24.54) v1(40.89,56.44) v1(40.92,52.58) v1(41.04,60.38) v1(41.02,58.35) v1(41.04,39.75) v1(40.97,1.7) v1(41.07,37.64) v1(41.17,82.58) v1(41.25,28.35) v1(41.17,23.09) v1(41.2,22.68) v1(41.3,47.02) v1(41.3,44.98) v1(41.3,26.19) v1(41.35,24.94) v1(41.32,24.51) v1(41.27,22.02) v1(41.3,21.36) v1(41.32,20.35) v1(41.3,19.33) v1(41.3,17.93) v1(41.3,16.66) v1(41.3,15.14) v1(41.3,13.74) v1(41.44,66.57) v1(41.44,65.81) v1(41.44,63.02) v1(41.44,61.24) v1(41.37,36.58) v1(41.47,83.59) v1(41.63,81.48) v1(41.68,23.09) v1(41.81,70.24) v1(41.81,69.1) v1(41.78,60.45) v1(41.81,58.05) v1(41.81,43.97) v1(41.81,24.94) v1(41.78,24.51) v1(41.75,22.71) v1(42.31,24.51) v1(42.26,23.09) v1(42.34,22.68) v1(42.44,82.58) v1(42.36,24.94) v1(42.36,3.74) v1(42.57,47.02) v1(42.62,23.09) v1(42.64,19.48) v1(42.62,17.45) v1(42.82,44.98) v1(42.85,29.95) v1(42.82,28.35) v1(42.85,25) v1(42.82,24.51) v1(42.95,83.62) v1(42.95,6) v1(42.95,4.98) v1(42.97,80.65) v1(43.02,23.09) v1(42.97,22.66) v1(43.02,22.2) v1(43.08,21.11) v1(43.13,20.07) v1(43.2,19.2) v1(43.2,18.7) v1(43.2,18.06) v1(43.3,81.46) v1(43.3,25) v1(43.25,24.51) v1(43.41,35.18) v1(43.41,21.34) v1(43.41,20.83) v1(43.41,20.32) v1(43.43,19.81) v1(43.46,43.84) v1(43.46,42.37) v1(43.46,37.42) v1(43.46,23.06) v1(43.46,22.61) v1(43.46,22.2) v1(43.46,21.77) v1(43.53,17.65) v1(43.71,82.7) v1(43.71,25.05) v1(43.74,24.51) v1(43.84,47.02) v1(43.89,17.15) v1(44.24,25.15) v1(44.22,24.58) v1(44.22,17.72) v1(44.47,28.35) v1(44.6,82.83) v1(44.6,44.86) v1(44.6,43.84) v1(44.6,42.57) v1(44.6,41.3) v1(44.6,36.98) v1(44.57,35.82) v1(44.6,34.44) v1(44.62,32.44) v1(44.6,31.52) v1(44.6,30.51) v1(44.6,29.36) v1(44.75,24.51) v1(44.83,17.6) v1(44.93,25.05) v1(44.98,24.11) v1(44.98,23.6) v1(44.98,23.12) v1(44.98,22.66) v1(44.98,22.2) v1(44.98,21.69) v1(45.02,20.98) v1(44.98,20.37) v1(44.98,19.89) v1(45.08,80.62) v1(45.11,47.02) v1(45.13,24.66) v1(45.11,19.2) v1(45.11,18.7) v1(45.11,18.06) v1(45.16,83.75) v1(45.15,67.27) v1(45.15,65.58) v1(45.34,24.11) v1(45.31,23.09) v1(45.31,22.63) v1(45.34,21.69) v1(45.44,67.56) v1(45.44,66.99) v1(45.44,65.86) v1(45.36,23.6) v1(45.36,22.15) v1(45.41,20.27) v1(45.39,19.81) v1(45.62,45.49) v1(45.72,67.27) v1(45.72,66.14) v1(45.72,65.58) v1(45.87,82.7) v1(46,67.56) v1(46.05,34.6) v1(46.07,81.31) v1(46.2,79.05) v1(46.22,43.16) v1(46.38,47.02) v1(46.57,68.69) v1(46.57,67.56) v1(46.58,33.17) v1(46.89,43.21) v1(47.01,82.7) v1(47.4,68.45) v1(47.4,67.5) v1(47.4,66.54) v1(47.4,65.59) v1(47.4,64.64) v1(47.4,63.69) v1(47.4,61.78) v1(47.4,60.83) v1(47.4,59.87) v1(47.55,43.44) v1(47.65,47.02) v1(47.65,41.07) v1(47.72,79.07) v1(47.67,77.55) v1(47.67,67.97) v1(47.67,67.02) v1(47.67,65.11) v1(47.67,62.26) v1(47.67,60.35) v1(47.67,37.95) v1(47.88,81.38) v1(47.95,67.5) v1(47.95,65.59) v1(47.95,63.69) v1(47.95,59.87) v1(47.9,45.49) v1(47.9,33.17) v1(48.22,67.97) v1(48.22,67.02) v1(48.22,65.11) v1(48.22,64.16) v1(48.22,62.26) v1(48.22,61.3) v1(48.22,60.35) v1(48.5,67.5) v1(48.5,66.54) v1(48.5,65.59) v1(48.5,64.64) v1(48.5,63.69) v1(48.5,62.73) v1(48.5,61.78) v1(48.5,60.83) v1(48.5,59.87) v1(48.61,39.8) v1(48.71,83.54) v1(48.65,40.54) v1(48.83,70.39) v1(48.83,69.82) v1(48.83,69.26) v1(48.77,67.97) v1(48.77,67.02) v1(48.77,66.07) v1(48.77,65.11) v1(48.77,64.16) v1(48.77,63.21) v1(48.77,62.26) v1(48.77,60.35) v1(48.82,49.2) v1(48.92,82.83) v1(48.92,53.89) v1(48.92,47.02) v1(49.05,68.45) v1(49.05,66.54) v1(49.05,65.59) v1(49.05,64.64) v1(49.05,63.69) v1(49.05,62.73) v1(49.05,59.87) v1(48.99,41.3) v1(49.11,70.67) v1(49.11,70.1) v1(49.32,81.41) v1(49.32,66.07) v1(49.32,63.21) v1(49.32,62.26) v1(49.4,70.39) v1(49.43,44.98) v1(49.37,33.15) v1(49.58,79.2) v1(49.6,68.45) v1(49.6,67.5) v1(49.6,66.54) v1(49.6,65.59) v1(49.6,63.69) v1(49.6,59.87) v1(49.81,82.7) v1(49.87,65.11) v1(49.87,63.21) v1(49.87,62.26) v1(49.87,61.3) v1(49.98,73) v1(49.98,72.67) v1(50.15,68.45) v1(50.15,60.83) v1(50.19,53.93) v1(50.19,47.02) v1(50.42,62.26) v1(50.44,52.55) v1(50.42,41.28) v1(50.52,43.18) v1(50.45,40.54) v1(50.47,39.7) v1(50.7,68.45) v1(50.7,67.5) v1(50.7,63.69) v1(50.7,60.83) v1(50.7,59.87) v1(50.72,33.17) v1(50.97,67.02) v1(50.97,64.16) v1(50.97,62.26) v1(50.97,61.3) v1(51,44.98) v1(51.36,37.67) v1(51.52,65.11) v1(51.52,62.26) v1(51.52,61.3) v1(51.46,47.02) v1(51.56,78.13) v1(51.58,49.09) v1(51.66,77.37) v1(51.66,58.5) v1(51.84,82.83) v1(51.8,66.54) v1(51.8,64.64) v1(51.8,62.73) v1(51.8,60.83) v1(51.8,59.87) v1(51.94,33.17) v1(52.07,67.97) v1(52.07,67.02) v1(52.07,66.07) v1(52.07,65.11) v1(52.07,64.16) v1(52.07,63.21) v1(52.19,41.3) v1(52.24,39.8) v1(52.35,67.5) v1(52.35,66.54) v1(52.35,63.69) v1(52.35,60.83) v1(52.35,59.87) v1(52.27,43.18) v1(52.25,40.54) v1(52.55,81.54) v1(52.51,58.22) v1(52.51,57.65) v1(52.62,67.97) v1(52.62,67.02) v1(52.62,61.3) v1(52.6,47.02) v1(52.65,78.11) v1(52.75,44.98) v1(52.85,74.78) v1(52.9,68.45) v1(52.9,62.73) v1(52.9,59.87) v1(52.98,33.15) v1(53.09,82.98) v1(53.17,67.97) v1(53.17,66.07) v1(53.17,65.11) v1(53.17,64.16) v1(53.17,63.21) v1(53.17,61.3) v1(53.36,82.45) v1(53.45,66.54) v1(53.45,65.59) v1(53.45,64.64) v1(53.45,63.69) v1(53.45,61.78) v1(53.45,60.83) v1(53.45,59.87) v1(53.57,74.93) v1(53.72,67.97) v1(54,59.87) v1(54,44.93) v1(54,43.13) v1(54.02,41.4) v1(54,33.15) v1(54.05,40.54) v1(54.27,67.97) v1(54.51,84.05) v1(54.51,82.58) v1(54.55,67.5) v1(54.55,59.87) v1(54.62,54.38) v1(54.73,82) v1(54.82,67.02) v1(54.82,66.07) v1(54.82,65.11) v1(54.82,64.16) v1(54.82,62.26) v1(54.82,61.3) v1(54.82,60.35) v1(54.77,58.22) v1(54.77,57.65) v1(55.01,33.15) v1(55.1,67.5) v1(55.1,65.59) v1(55.1,64.64) v1(55.1,63.69) v1(55.1,61.78) v1(55.1,60.83) v1(55.1,59.87) v1(55.06,57.94) v1(55.19,78.13) v1(55.27,81.81) v1(55.34,58.22) v1(55.37,67.97) v1(55.37,67.02) v1(55.37,65.11) v1(55.37,64.16) v1(55.37,62.26) v1(55.37,61.3) v1(55.37,60.35) v1(55.52,46.76) v1(55.65,67.5) v1(55.65,66.54) v1(55.65,64.64) v1(55.65,62.73) v1(55.65,59.87) v1(55.65,39.6) v1(55.7,83.36) v1(55.72,44.96) v1(55.79,73.94) v1(55.78,43.08) v1(55.92,67.02) v1(55.92,66.07) v1(55.92,63.21) v1(55.92,61.3) v1(55.85,41.23) v1(55.85,40.54) v1(56.03,33.15) v1(56.18,79.25) v1(56.79,44.98) v1(57.05,79.91) v1(57.05,33.15) v1(57.2,39.55) v1(57.4,78.34) v1(57.6,63.31) v1(58.01,44.96) v1(58.06,43.97) v1(58.11,41.66) v1(58.06,33.15) v1(58.21,42.67) v1(58.71,74.32) v1(58.82,50.83) v1(58.89,75.72) v1(59.08,33.15) v1(59.18,35.76) v1(59.36,42.55) v1(59.71,74.8) v1(59.66,69.26) v1(59.71,46.76) v1(60.09,33.15) v1(60.4,41.4) v1(60.47,72.8) v1(60.98,73.56) v1(61.03,72.01) v1(61.11,33.15) v1(61.49,63.92) v1(61.49,62.78) v1(61.49,60.87) v1(61.49,59.73) v1(61.49,58.59) v1(61.62,74.02) v1(61.87,46.76) v1(61.98,70.21) v1(61.98,68.86) v1(61.98,68.1) v1(61.98,67.21) v1(61.98,66.45) v1(61.98,65.05) v1(62.11,75.72) v1(62.13,33.15) v1(62.25,58.57) v1(62.51,79.66) v1(62.48,75.9) v1(62.51,74.21) v1(62.68,46.76) v1(62.91,41.17) v1(63.14,33.15) v1(63.38,69.75) v1(63.73,44.5) v1(63.7,43.92) v1(63.73,42.72) v1(63.8,78.11) v1(63.82,72.52) v1(63.82,71.65) v1(63.82,70.77) v1(63.82,67.34) v1(63.83,66.45) v1(63.78,46.76) v1(63.75,45.01) v1(63.9,64.4) v1(63.9,60.86) v1(64.03,63.26) v1(64.03,61.38) v1(64.03,35.59) v1(64.11,83.39) v1(64.16,33.15) v1(64.41,78.03) v1(64.67,81.81) v1(64.84,64.29) v1(64.79,46.76) v1(64.94,84.08) v1(64.87,63.43) v1(64.94,60.02) v1(64.96,71.63) v1(65.17,79.66) v1(65.17,73.85) v1(65.17,33.15) v1(65.33,64.31) v1(65.33,63.45) v1(65.38,76.94) v1(65.43,52.38) v1(65.78,66.42) v1(65.94,46.51) v1(65.94,45.24) v1(65.94,43.97) v1(65.94,42.7) v1(65.94,41.43) v1(65.94,40.16) v1(65.94,38.89) v1(65.94,37.62) v1(65.94,36.35) v1(65.94,35.08) v1(66.19,33.15) v1(66.29,53.49) v1(66.49,62.13) v1(66.52,61.32) v1(66.62,83.64) v1(66.57,80.04) v1(66.85,76.05) v1(66.98,78.31) v1(67.03,61.29) v1(67.05,62.13) v1(67.1,36.6) v1(67.21,33.15) v1(67.76,84.63) v1(68.2,78.39) v1(68.22,33.15) v1(68.91,35.03) v1(69.14,76.99) v1(69.14,75.97) v1(69.24,33.15) v1(69.64,78.44) v1(70.2,82.3) v1(70.2,46.53) v1(70.2,45.8) v1(70.18,42.44) v1(70.18,41.68) v1(70.15,40.13) v1(70.18,39.73) v1(70.3,84.66) v1(70.25,33.15) v1(70.35,44.6) v1(70.35,44.27) v1(70.56,75.87) v1(70.58,46.53) v1(70.56,45.8) v1(70.63,42.42) v1(70.61,41.66) v1(70.61,40.13) v1(70.63,39.73) v1(70.86,44.6) v1(70.86,44.27) v1(71.02,48.26) v1(71.24,78.31) v1(71.35,81.13) v1(71.27,33.15) v1(72.29,33.15) v1(72.41,77.04) v1(72.41,44.86) v1(72.41,44.35) v1(72.92,44.86) v1(72.92,44.35) v1(73.02,33.15) v1(73.2,81.36) v1(73.28,78.31) v1(73.38,86.56) v1(73.43,44.86) v1(73.43,44.35) v1(73.66,84.38) v1(73.68,73.08) v1(73.68,72.49) v1(73.78,77.01) v1(74.04,33.15) v1(74.14,73.08) v1(74.14,72.52) v1(74.39,65.05) v1(74.39,64.59) v1(74.44,63.37) v1(74.39,62.46) v1(74.42,53.95) v1(74.39,53.52) v1(74.39,53.09) v1(74.7,73.1) v1(74.7,72.52) v1(74.85,83.11) v1(74.93,65.05) v1(74.88,53.95) v1(74.88,53.52) v1(74.88,53.09) v1(74.95,64.57) v1(75.02,63.4) v1(74.98,62.46) v1(75.13,77.07) v1(75.05,33.15) v1(75.18,49.33) v1(75.21,48.85) v1(75.18,44.98) v1(75.18,44.55) v1(75.54,81.33) v1(75.49,78.31) v1(75.59,44.98) v1(75.59,44.48) v1(75.69,73.08) v1(75.71,72.47) v1(75.66,49.35) v1(75.66,48.82) v1(75.82,86.62) v1(75.79,84.81) v1(75.97,44.98) v1(75.97,44.48) v1(76.07,33.15) v1(76.2,72.49) v1(76.22,71.07) v1(76.22,70.46) v1(76.2,65.23) v1(76.22,64.8) v1(76.18,63.5) v1(76.35,60.68) v1(76.32,60.22) v1(76.35,55.45) v1(76.35,55.04) v1(76.3,53.82) v1(76.27,53.37) v1(76.54,63.5) v1(76.58,65.23) v1(76.73,73.08) v1(76.73,72.49) v1(76.7,71.07) v1(76.7,70.46) v1(76.73,60.49) v1(76.68,55.48) v1(76.68,55.04) v1(76.73,53.82) v1(76.73,53.34) v1(76.86,77.01) v1(76.93,65.23) v1(76.86,64.8) v1(76.92,63.5) v1(77.14,60.73) v1(77.14,60.2) v1(77.06,55.45) v1(77.06,55.04) v1(77.11,53.8) v1(77.14,53.34) v1(77.09,33.15) v1(77.19,78.31) v1(77.21,71.07) v1(77.21,70.49) v1(77.26,65.23) v1(77.28,63.5) v1(77.37,48.29) v1(77.73,63.47) v1(77.9,81.05) v1(78.1,33.15) v1(78.17,63.49) v1(78.33,55.83) v1(78.33,54.87) v1(78.41,71.35) v1(78.41,70.66) v1(78.38,65.41) v1(78.41,49.91) v1(78.41,49.1) v1(78.46,60.61) v1(78.71,55.83) v1(78.71,54.87) v1(78.81,70.66) v1(78.81,49.91) v1(78.79,49.1) v1(78.86,71.32) v1(79.12,33.15) v1(79.65,84.56) v1(80.01,82.15) v1(80.13,33.15) v1(80.87,53.77) v1(81.1,81.05) v1(81.15,33.15) v1(81.3,53.77) v1(81.63,82.17) v1(81.76,53.75) v1(81.78,49.86) v1(81.81,49.23) v1(81.94,44.56) v1(81.9,38.63) v1(82.17,33.15) v1(82.34,84.25) v1(82.32,49.86) v1(82.29,49.23) v1(82.8,80.9) v1(82.85,73.23) v1(82.9,72.65) v1(83.23,82.96) v1(83.15,43.53) v1(83.18,33.15) v1(83.31,73.23) v1(83.36,72.65) v1(83.54,71.4) v1(83.51,57.15) v1(83.56,70.87) v1(83.56,70.38) v1(83.61,55.4) v1(83.59,54.97) v1(83.82,73.23) v1(83.84,72.65) v1(83.97,71.4) v1(83.97,70.87) v1(83.97,70.38) v1(84.02,55.32) v1(83.99,54.94) v1(84.2,33.15) v1(84.4,81.56) v1(84.53,37.63) v1(84.88,57.63) v1(84.88,57.25) v1(85.06,83.42) v1(85.21,71.4) v1(85.21,70.92) v1(85.24,70.33) v1(85.16,52.91) v1(85.21,52) v1(85.19,50.78) v1(85.21,33.15) v1(85.29,80.8) v1(85.26,68.43) v1(85.47,68.15) v1(85.54,50.45) v1(85.62,52.91) v1(85.62,51.64) v1(85.55,44.48) v1(85.62,42.23) v1(85.8,71.4) v1(85.8,70.94) v1(85.77,70.33) v1(86.23,33.15) v1(86.29,35.59) v1(86.26,34.06) v1(86.51,42.23) v1(86.74,76.91) v1(87.12,80.95) v1(87.17,82.93) v1(87.25,33.15) v1(87.4,42.23) v1(87.53,34.06) v1(87.63,60.5) v1(87.63,60.15) v1(87.69,45.49) v1(87.96,40.21) v1(88.26,33.15) v1(88.46,80.98) v1(88.49,57.66) v1(88.49,57.2) v1(88.57,39.14) v1(88.57,38.76) v1(88.59,38.38) v1(88.59,38) v1(88.77,57.43) v1(88.8,34.06) v1(88.92,39.14) v1(88.92,38.76) v1(88.92,38.38) v1(88.92,38) v1(89.05,57.66) v1(89.05,57.2) v1(89.13,40.57) v1(89.2,82.78) v1(89.33,73.61) v1(89.3,69.04) v1(89.33,68.68) v1(89.3,39.14) v1(89.3,38.76) v1(89.3,38.38) v1(89.3,38) v1(89.28,33.15) v1(89.66,43.61) v1(89.76,69.04) v1(89.76,68.66) v1(89.79,59.39) v1(89.86,64.03) v1(89.86,63.68) v1(89.91,43.36) v1(89.96,73.23) v1(90.01,72.75) v1(90.04,56.64) v1(90.04,52.48) v1(90.01,51.51) v1(90.04,50.29) v1(90.04,49.84) v1(90.01,49.35) v1(90.01,48.13) v1(90.04,47.68) v1(90.04,47.17) v1(90.07,34.06) v1(90.19,59.39) v1(90.27,64.03) v1(90.27,63.68) v1(90.29,33.15) v1(90.62,73.23) v1(90.6,72.75) v1(90.6,54.21) v1(90.6,53.77) v1(90.65,52.48) v1(90.62,51.51) v1(90.62,50.29) v1(90.6,49.84) v1(90.62,49.35) v1(90.62,48.13) v1(90.6,47.65) v1(90.62,47.14) v1(90.93,81.94) v1(91.13,64.06) v1(91.13,63.73) v1(91.21,34.06) v1(91.34,54.21) v1(91.34,53.77) v1(91.28,39.22) v1(91.31,33.15) v1(91.36,81.1) v1(91.51,64.06) v1(91.51,63.73) v1(91.72,79.78) v1(91.82,71.27) v1(91.84,47.65) v1(92.17,71.73) v1(92.2,38.18) v1(92.25,35.82) v1(92.33,33.15) v1(92.38,53.57) v1(92.4,53.19) v1(92.38,52.27) v1(92.38,51.92) v1(92.48,82.93) v1(92.48,34.06) v1(92.55,78.46) v1(92.64,50.19) v1(92.62,49.33) v1(92.86,79.78) v1(92.88,53.57) v1(92.88,53.19) v1(92.86,52.27) v1(92.86,51.92) v1(93.21,71.63) v1(93.32,74.27) v1(93.27,72.24) v1(93.34,33.15) v1(93.47,67.9) v1(93.49,48.41) v1(93.72,75.34) v1(93.75,74.83) v1(93.7,73.81) v1(93.7,73.28) v1(93.7,72.8) v1(93.75,40.12) v1(93.75,34.06) v1(93.77,84.63) v1(93.85,58.4) v1(93.85,58.02) v1(93.85,57.25) v1(93.85,56.87) v1(93.85,56.11) v1(93.85,55.7) v1(93.88,81.05) v1(94.13,79.78) v1(94.21,37.75) v1(94.23,37.29) v1(94.31,75.36) v1(94.33,74.86) v1(94.31,73.79) v1(94.33,73.38) v1(94.33,72.82) v1(94.33,57.25) v1(94.33,56.87) v1(94.43,61.34) v1(94.43,59.59) v1(94.36,58.4) v1(94.36,58.02) v1(94.36,56.11) v1(94.36,55.7) v1(94.36,33.15) v1(94.56,37.75) v1(94.56,37.29) v1(95.02,34.06) v1(95.12,64.03) v1(95.35,78.28) v1(95.3,35.46) v1(95.4,79.78) v1(95.37,33.15) v1(95.53,38.23) v1(95.53,36.43) v1(95.75,63.35) v1(96.16,34.06) v1(96.34,37.29) v1(96.39,33.15) v1(96.47,78.34) v1(96.49,64.16) v1(96.59,72.29) v1(96.64,70.18) v1(96.64,68.28) v1(96.67,79.78) v1(96.67,73.97) v1(96.85,62.08) v1(96.9,59.89) v1(97.13,72.87) v1(97.13,67.39) v1(97.13,53.06) v1(97.23,75.36) v1(97.2,74.93) v1(97.15,73.76) v1(97.23,71.73) v1(97.2,71.05) v1(97.18,69.6) v1(97.18,68.94) v1(97.15,66.7) v1(97.15,59.41) v1(97.15,59.01) v1(97.15,58.14) v1(97.15,57.74) v1(97.15,56.87) v1(97.15,56.47) v1(97.15,55.6) v1(97.15,55.17) v1(97.15,54.33) v1(97.15,53.93) v1(97.15,52.66) v1(97.15,51.82) v1(97.15,51.39) v1(97.41,33.15) v1(97.51,73.71) v1(97.51,72.87) v1(97.53,67.59) v1(97.53,66.91) v1(97.61,75.24) v1(97.61,74.86) v1(97.58,71.71) v1(97.58,71.05) v1(97.56,69.6) v1(97.56,68.94) v1(97.66,59.41) v1(97.66,59.01) v1(97.66,58.14) v1(97.66,57.74) v1(97.66,56.87) v1(97.66,56.47) v1(97.66,55.6) v1(97.66,55.2) v1(97.66,54.33) v1(97.66,53.93) v1(97.66,53.09) v1(97.66,52.66) v1(97.66,51.82) v1(97.66,51.39) v1(97.94,79.78) v1(98.07,34.06) v1(98.19,42.75) v1(98.42,33.15) v1(98.52,57.61) v1(98.52,57.1) v1(98.52,56.59) v1(98.47,35.36) v1(98.62,37.64) v1(98.83,39.02) v1(98.98,44.98) v1(98.96,37.59) v1(99.13,35.36) v1(99.21,79.78) v1(99.18,57.61) v1(99.16,57.1) v1(99.18,56.57) v1(99.34,38.43) v1(99.34,34.06) v1(99.44,33.15) v1(99.56,61.49) v1(99.79,35.38) v1(99.92,76.51) v1(99.95,75.74) v1(99.92,74.91) v1(100.02,59.89) v1(100.1,58.8) v1(100.15,39.17) v1(100.23,44.73) v1(100.33,58.55) v1(100.28,58.14) v1(100.38,59.39) v1(100.43,35.41) v1(100.48,79.78) v1(100.45,33.15) v1(100.61,34.06) v1(100.81,77.37) v1(100.83,75.8) v1(100.81,74.88) v1(100.86,76.51) v1(101.34,60.5) v1(101.47,60.1) v1(101.47,33.15) v1(101.62,79.78) v1(101.75,82.83) v1(101.75,42.72) v1(101.8,78.31) v1(101.93,46.97) v1(101.88,34.06) v1(102.1,36.15) v1(102.49,45.47) v1(102.49,33.15) v1(102.82,85.09) v1(102.82,82.15) v1(102.82,50.19) v1(102.89,79.78) v1(102.89,78.87) v1(102.92,60.05) v1(103.02,66.19) v1(103.02,34.06) v1(103.2,80.9) v1(103.2,44.81) v1(103.27,38.89) v1(103.37,33.15) v1(103.65,82.6) v1(103.91,79.78) v1(104.04,42.44) v1(104.21,46.36) v1(104.16,34.06) v1(104.57,43.79) v1(104.67,83.72) v1(104.77,81.26) v1(104.8,45.9) v1(104.92,79.78) v1(105.18,39.65) v1(105.18,38.38) v1(105.18,37.11) v1(105.18,35.84) v1(105.18,34.32) v1(105.64,82.78) v1(105.56,40.79) v1(105.74,85.14) v1(106.07,79.78) v1(106.23,73.43) v1(106.3,72.04) v1(106.3,71.53) v1(106.3,71.02) v1(106.3,70.51) v1(106.3,70) v1(106.32,46.46) v1(106.81,72.04) v1(106.81,71.53) v1(106.81,71.02) v1(106.81,70.51) v1(106.81,70) v1(106.78,68.73) v1(106.8,68.15) v1(106.78,67.69) v1(106.83,66.7) v1(106.83,66.19) v1(106.83,65.69) v1(106.78,39.24) v1(107.08,79.78) v1(107.08,40.79) v1(107.21,66.7) v1(107.25,61.37) v1(107.21,46.46) v1(107.34,83.59) v1(107.29,75.74) v1(107.32,72.04) v1(107.32,71.53) v1(107.32,71.02) v1(107.32,70.51) v1(107.32,70) v1(107.34,68.73) v1(107.34,67.97) v1(107.34,66.19) v1(107.34,65.69) v1(107.31,37.9) v1(107.39,74.86) v1(107.64,82.68) v1(107.85,79.78) v1(107.92,75.74) v1(107.97,74.83) v1(108.05,38.84) v1(108.2,81.23) v1(108.35,40.79) v1(108.46,70.51) v1(108.48,65.94) v1(108.76,52.96) v1(108.86,79.78) v1(109.04,39.14) v1(109.75,40.79) v1(110,83.21) v1(110,81.94) v1(110,80.8) v1(110,79.78) v1(109.98,71.35) v1(110.13,76.23) v1(110.13,75.34) v1(110.09,66.96) v1(110.26,64.81) v1(110.49,85.14) v1(110.64,83.85) v1(110.64,70.51) v1(110.89,72.29) v1(111.02,77.75) v1(110.99,67.92) v1(111.02,56.95) v1(111.02,40.79) v1(111.15,65.29) v1(111.1,54.97) v1(111.4,85.24) v1(111.4,75.08) v1(111.4,73.94) v1(111.4,69.76) v1(111.53,77.5) v1(111.5,76.53) v1(111.5,76.15) v1(111.78,82.55) v1(111.78,72.29) v1(111.91,83.85) v1(112.09,66.68) v1(112.16,62.51) v1(112.16,61.49) v1(112.16,60.73) v1(112.16,59.59) v1(112.16,58.7) v1(112.16,57.68) v1(112.16,56.54) v1(112.16,55.53) v1(112.16,54.51) v1(112.16,53.37) v1(112.16,52.48) v1(112.16,51.46) v1(112.16,50.45) v1(112.16,49.3) v1(112.16,48.03) v1(112.16,46.76) v1(112.16,45.75) v1(112.16,44.48) v1(112.16,43.21) v1(112.16,41.94) v1(112.16,40.79) v1(112.29,73.94) v1(112.62,81.87) v1(112.62,81.51) v1(112.62,38.28) v1(112.72,37.31) v1(112.8,66.7) v1(113.1,56.64) v1(113.18,83.85) v1(113.23,82.53) v1(113.18,81.87) v1(113.18,81.51) v1(113.33,85.14) v1(113.36,55.53) v1(113.36,55.04) v1(113.64,34.22) v1(113.74,81.51) v1(113.69,66.7) v1(113.76,36.6) v1(114.07,63.27) v1(114.45,83.85) v1(114.63,82.58) v1(114.58,66.7) v1(114.58,37.47) v1(114.86,34.37) v1(114.96,63.27) v1(115.1,80.42) v1(115.06,56.34) v1(115.34,61.27) v1(115.47,83.85) v1(115.52,82.61) v1(115.47,66.7) v1(115.47,61.85) v1(115.62,48.87) v1(115.62,47.7) v1(115.57,46.05) v1(115.82,55.42) v1(115.82,42.83) v1(115.9,59.84) v1(115.97,73.03) v1(116.05,71.88) v1(115.97,63.27) v1(116.07,71.07) v1(116.07,58.95) v1(116.3,85.17) v1(116.35,66.7) v1(116.43,52.3) v1(116.38,37.9) v1(116.53,49.71) v1(116.61,47.6) v1(116.74,83.85) v1(116.71,41.86) v1(116.66,41.2) v1(116.71,39.27) v1(116.86,63.27) v1(117.04,71.91) v1(116.99,56.34) v1(117.01,50.93) v1(117.09,73) v1(117.09,71.12) v1(117.14,45.77) v1(117.14,43.56) v1(117.24,81.55) v1(117.24,66.7) v1(117.34,83.81) v1(117.32,37.11) v1(117.41,56.92) v1(117.85,71.96) v1(117.9,71.15) v1(117.88,63.27) v1(117.93,55.55) v1(118.01,83.85) v1(118.18,39.37) v1(118.31,49.89) v1(118.39,72.98) v1(118.5,83.83) v1(118.49,51.16) v1(118.72,58.24) v1(118.72,36.17) v1(118.72,35.36) v1(118.84,71.96) v1(118.84,71.12) v1(118.89,63.27) v1(118.89,56.26) v1(118.87,55.63) v1(119.02,83.85) v1(119.03,73.37) v1(119.12,85.17) v1(119.15,61.28) v1(119.12,46.1) v1(119.3,57.84) v1(119.47,35.76) v1(119.58,83.85) v1(119.73,52.38) v1(119.78,44.48) v1(119.91,82.36) v1(119.91,63.27) v1(119.94,34.32) v1(120.09,56.24) v1(120.06,55.63) v1(120.09,42.72) v1(120.24,36.17) v1(120.21,35.38) v1(120.29,83.85) v1(120.57,58.32) v1(120.75,63.04) v1(120.85,85.19) v1(120.8,82.36) v1(120.88,83.85) v1(121.08,38.48) v1(121.35,60.81) v1(121.26,49) v1(121.56,83.85) v1(121.56,56.82) v1(121.66,63.04) v1(121.76,36.4) v1(121.97,41.58) v1(122.12,57.68) v1(122.09,44.32) v1(122.22,83.87) v1(122.35,34.6) v1(122.4,52.43) v1(122.68,63.04) v1(122.83,83.85) v1(122.96,60.48) v1(123.09,58.37) v1(123.26,83.85) v1(123.69,83.82) v1(123.8,82.86) v1(123.82,62.99) v1(123.85,61.81) v1(123.77,59.56) v1(123.85,57.3) v1(124.1,83.85) v1(124.05,61.19) v1(124.56,57.63) v1(124.66,58.47) v1(124.99,63.27) v1(125.09,61.42) v1(125.24,83.85) v1(125.75,63.27) v1(125.78,56.49) v1(125.88,83.08) v1(125.88,82.07) v1(125.88,80.8) v1(125.88,69.37) v1(125.85,68.33) v1(125.88,67.08) v1(125.88,66.07) v1(125.88,65.18) v1(125.88,64.16) v1(125.9,60.81) v1(126.18,61.52) v1(126.62,69.19) v1(126.67,56.62) v1(126.84,69.9) v1(126.95,61.65) v1(127.12,59.64) v1(127.25,58.07) v1(127.91,71.35) v1(127.99,76.32) v1(128.04,60.1) v1(128.01,57.46) v1(128.27,79.35) v1(128.34,70.54) v1(128.42,84.23) v1(128.42,80.42) v1(128.44,55.27) v1(128.52,82.86) v1(128.5,68.35) v1(128.6,81.48) v1(128.8,66.02) v1(128.8,65) v1(128.8,63.98) v1(128.8,62.97) v1(128.8,61.95) v1(128.8,60.94) v1(128.8,59.92) v1(128.8,58.9) v1(128.8,57.89) v1(128.8,56.87) v1(128.8,55.86) v1(129.21,67.41) v1(129.69,79.33) v1(129.77,76.32) v1(130.02,84.48) v1(130.32,80.7) v1(130.65,76.32) v1(131.01,67.84) v1(131.39,82.55) v1(131.82,69.83) v1(131.92,79.17) v1(132.43,76.32) v1(132.53,84.2) v1(132.46,81.46) v1(132.58,68.3) v1(132.71,69.85) v1(133.45,79.2) v1(133.8,82.88) v1(134.26,79.22) v1(135.23,80.93) v1(135.56,69.42) v1(135.71,84.86) v1(135.66,79.61) v1(136.22,82.81) v1(136.78,79.25) v1(136.93,69.85) v1(137.59,68.38) v1(137.67,70.44) v1(137.84,82.02) v1(137.99,67.57) v1(138.12,84) v1(138.3,80.32) v1(138.3,78.92) v1(138.45,80.77) v1(138.55,71.27) v1(138.6,70.11) v1(139.01,67.57) v1(139.09,78.06) v1(139.21,68.91) v1(139.52,84.63) v1(139.62,81.74) v1(139.7,83.19) v1(140.03,67.57) v1(140.43,71.15) v1(141.04,67.57) v1(141.17,69.93) v1(141.42,71.4) v1(141.83,85.45) v1(141.86,85.04) v1(142.06,67.57) v1(142.19,85.42) v1(142.21,84.91) v1(142.26,74.88) v1(142.26,74.32) v1(142.36,68.45) v1(142.52,84.65) v1(142.52,83.82) v1(142.54,82.83) v1(142.9,70.61) v1(143.02,86.16) v1(143.07,73.11) v1(143.07,67.57) v1(143.23,85.29) v1(143.25,84.91) v1(143.53,71.76) v1(143.63,84.99) v1(143.63,82.5) v1(143.66,85.32) v1(143.66,82.15) v1(143.76,74.88) v1(143.76,74.42) v1(144.04,85.32) v1(144.04,84.99) v1(143.99,82.5) v1(143.99,82.15) v1(144.09,67.57) v1(144.4,85.68) v1(144.45,85.32) v1(144.45,84.99) v1(144.4,82.48) v1(144.42,82.15) v1(144.52,68.4) v1(144.7,86.08) v1(144.8,85.32) v1(144.8,84.99) v1(144.78,82.5) v1(144.78,82.17) v1(145.13,82.5) v1(145.13,82.15) v1(145.11,67.57) v1(145.16,85.35) v1(145.18,84.96) v1(145.26,74.86) v1(145.26,74.42) v1(145.84,70.44) v1(146.12,67.57) v1(146.71,83.97) v1(146.71,82.7) v1(146.71,81.43) v1(146.71,80.16) v1(146.71,78.89) v1(146.71,77.62) v1(146.83,76.61) v1(146.96,85.62) v1(147.14,67.57) v1(147.34,85.65) v1(147.37,68.78) v1(147.52,71.32) v1(147.6,84.48) v1(148.1,76.61) v1(148.1,72.29) v1(148.15,86.16) v1(148.19,82.93) v1(148.19,82.04) v1(148.15,67.57) v1(148.49,85.62) v1(148.58,70.46) v1(148.74,68.48) v1(148.87,84.48) v1(149.25,68.73) v1(149.17,67.57) v1(149.32,69.39) v1(149.37,85.6) v1(149.37,76.61) v1(149.5,78.87) v1(149.68,73.08) v1(150.01,68.99) v1(150.14,84.48) v1(150.26,69.62) v1(150.54,86.18) v1(150.64,76.61) v1(150.64,70) v1(150.9,78) v1(151.33,68.33) v1(151.33,67.97) v1(151.33,67.64) v1(151.3,67.29) v1(151.33,66.96) v1(151.41,84.48) v1(151.39,69.01) v1(151.36,68.68) v1(151.46,69.34) v1(151.58,69.7) v1(151.71,70) v1(151.84,70.31) v1(151.79,66.65) v1(151.86,76.25) v1(151.86,74.98) v1(151.86,73.71) v1(151.89,73.05) v1(151.86,72.44) v1(152.04,84.51) v1(151.99,70.61) v1(152.14,66.65) v1(152.19,70.92) v1(152.42,71.2) v1(152.5,66.65) v1(152.68,84.48) v1(152.65,71.48) v1(152.8,68.91) v1(152.78,68.58) v1(152.78,68.25) v1(152.93,71.71) v1(152.85,69.24) v1(152.85,66.65) v1(152.98,69.55) v1(153.13,69.85) v1(153.11,68.25) v1(153.16,71.96) v1(153.21,66.65) v1(153.31,86.16) v1(153.26,84.69) v1(153.29,70.16) v1(153.34,68.71) v1(153.41,72.19) v1(153.51,70.41) v1(153.57,66.65) v1(153.67,72.42) v1(153.67,68.38) v1(153.77,70.66) v1(153.95,86.13) v1(153.95,84.48) v1(153.92,66.65) v1(153.96,82.62) v1(153.96,79.02) v1(153.96,75.42) v1(153.96,74.52) v1(153.96,73.62) v1(153.96,72.72) v1(154,70.92) v1(154.02,68.38) v1(154.2,70) v1(154.28,72.39) v1(154.28,71.17) v1(154.28,66.65) v1(154.35,68.38) v1(154.53,71.43) v1(154.58,86.16) v1(154.56,72.14) v1(154.63,66.57) v1(154.71,68.48) v1(154.86,81.72) v1(154.86,74.52) v1(154.86,73.62) v1(154.86,72.72) v1(154.86,71.82) v1(154.99,66.6) v1(155.09,68.48) v1(155.22,84.48) v1(155.34,77.85) v1(155.34,70) v1(155.42,66.6) v1(155.47,68.45) v1(155.75,66.6) v1(155.76,74.52) v1(155.76,73.62) v1(155.76,72.72) v1(155.76,71.82) v1(155.85,68.51) v1(156.11,66.6) v1(156.23,70) v1(156.23,68.53) v1(156.49,84.48) v1(156.46,66.6) v1(156.66,82.62) v1(156.66,79.92) v1(156.66,75.42) v1(156.66,73.62) v1(156.66,72.72) v1(156.66,71.82) v1(156.71,68.53) v1(156.79,66.6) v1(156.99,70) v1(157.15,68.4) v1(157.15,67.72) v1(157.15,67.21) v1(157.17,66.65) v1(157.56,81.72) v1(157.56,80.82) v1(157.56,79.02) v1(157.56,76.32) v1(157.56,75.42) v1(157.56,74.52) v1(157.56,73.62) v1(157.56,72.72) v1(157.56,71.82) v1(157.76,84.48) v1(157.76,70) v1(158.46,80.82) v1(158.46,77.22) v1(158.46,75.42) v1(158.46,74.52) v1(158.46,73.62) v1(158.46,72.72) v1(158.46,71.82) v1(158.52,70) v1(158.9,84.48) v1(159.03,70) v1(159.36,76.32) v1(159.53,70) v1(160.17,84.48) v1(160.26,81.72) v1(160.26,79.92) v1(160.26,77.22) v1(160.26,75.42) v1(160.26,74.52) v1(160.26,73.62) v1(160.26,72.72) v1(160.26,71.82) v1(160.68,70) v1(160.93,68.45) v1(161.16,82.62) v1(161.16,80.82) v1(161.16,79.02) v1(161.16,78.12) v1(161.16,75.42) v1(161.16,74.52) v1(161.16,73.62) v1(161.16,72.72) v1(161.16,71.82) v1(161.44,84.48) v1(161.44,72.26) v1(161.49,71.45) v1(161.72,72.47) v1(161.77,71.2) v1(161.95,70) v1(162.06,82.62) v1(162.06,80.82) v1(162.06,79.01) v1(162.06,78.11) v1(162.06,77.22) v1(162.06,76.32) v1(162.06,75.42) v1(162.06,74.52) v1(162.06,73.62) v1(162.06,72.72) v1(162.1,71.12) v1(162.43,71.12) v1(162.56,72.49) v1(162.71,84.48) v1(162.81,71.12) v1(163.01,72.49) v1(162.96,68.99) v1(163.17,71.12) v1(163.22,70) v1(163.45,72.49) v1(163.5,71.12) v1(163.85,72.49) v1(163.88,71.12) v1(163.98,84.48) v1(164,84) v1(164,83.34) v1(164.11,82.7) v1(164.11,78.64) v1(164.11,77.37) v1(164.11,76.1) v1(164.11,74.83) v1(164.11,73.56) v1(164.11,70.51) v1(164.23,71.12) v1(164.26,72.49) v1(164.36,81.69) v1(164.36,80.8) v1(164.36,79.91) v1(164.64,72.49) v1(164.59,71.15) v1(164.94,71.15) v1(164.87,69.85) v1(165.02,72.49) v1(165.38,72.49) v1(165.35,71.15) v1(165.73,72.49) v1(165.76,81.21) v1(165.81,71.15) v1(166.11,72.49) v1(166.16,71.15) v1(166.49,72.49) v1(166.57,71.15) v1(166.85,72.47) v1(166.93,71.12) v1(167.13,68.99) v1(167.1,68.63) v1(167.1,68.28) v1(167.23,72.47) v1(167.15,70.11) v1(167.18,69.32) v1(167.23,67.67) v1(167.31,71.12) v1(167.31,70.79) v1(167.31,70.44) v1(167.31,69.8) v1(167.56,72.44) v1(167.92,72.47) v1(167.92,67.72) v1(168.32,72.42) v1(168.58,72.16) v1(168.55,67.67) v1(168.68,71.83) v1(168.68,71.5) v1(168.68,71.17) v1(168.68,70.82) v1(168.68,70.46) v1(168.68,70.13) v1(168.68,69.8) v1(168.83,69.45) v1(168.93,69.11) v1(168.93,68.68) v1(168.93,68.23) v1(168.96,67.64) v2(0.81,42.8) v2(1.42,45.37) v2(1.93,69.93) v2(1.9,67.24) v2(1.93,64.77) v2(1.98,43.66) v2(2.05,73.28) v2(2.13,47.96) v2(2.18,47.27) v2(2.54,62.94) v2(2.84,71.78) v2(2.92,64.26) v2(2.94,42.72) v2(3.07,74.83) v2(3.2,43.36) v2(3.32,75.82) v2(3.35,68.4) v2(3.6,48.19) v2(3.68,49.86) v2(3.73,49.4) v2(3.91,65.21) v2(4.11,63.51) v2(4.16,42.42) v2(4.34,49.84) v2(4.34,46.41) v2(4.37,43.38) v2(4.59,73.69) v2(4.7,49.05) v2(4.85,72.92) v2(4.82,71.73) v2(4.95,70.74) v2(4.95,65.69) v2(4.9,62.51) v2(5.03,49.86) v2(5.08,64.11) v2(5.1,43.03) v2(5.23,75.24) v2(5.2,69.32) v2(5.38,48.36) v2(5.53,47.17) v2(5.71,49.84) v2(5.81,70.59) v2(6.19,72.82) v2(6.3,74.12) v2(6.37,69.7) v2(6.41,64.67) v2(6.45,49.84) v2(6.85,48.39) v2(6.91,43.03) v2(6.96,68.58) v2(6.99,67.91) v2(7.21,49.84) v2(7.29,46.33) v2(7.36,72.67) v2(7.36,70.69) v2(7.82,48.34) v2(7.95,49.84) v2(8.02,69.32) v2(8.38,68.43) v2(8.38,46.92) v2(8.71,49.84) v2(8.99,70.87) v2(9.06,74.17) v2(9.22,46.97) v2(9.39,48.67) v2(9.52,75.34) v2(9.52,49.81) v2(9.57,67.21) v2(9.62,63.43) v2(9.75,82.83) v2(9.75,65.48) v2(9.75,43.08) v2(10.31,78.28) v2(10.31,72.47) v2(10.28,49.79) v2(10.35,45.24) v2(10.41,76.28) v2(10.36,69.19) v2(10.46,77.17) v2(10.49,70.72) v2(10.46,67.34) v2(10.46,44.22) v2(10.61,78.94) v2(10.59,73.46) v2(10.64,66.19) v2(10.66,74.55) v2(10.92,42.95) v2(11.1,48.52) v2(11.3,49.76) v2(11.38,74.73) v2(11.38,47.32) v2(11.5,65.46) v2(11.45,63.37) v2(11.45,42.95) v2(11.55,44.58) v2(11.68,82.12) v2(11.83,80.6) v2(11.91,63.91) v2(11.88,49.76) v2(12.14,60.33) v2(12.14,59.31) v2(12.14,58.29) v2(12.14,57.28) v2(12.14,56.26) v2(12.14,55.25) v2(12.14,54.23) v2(12.14,53.21) v2(12.14,52.2) v2(12.14,51.18) v2(12.14,50.17) v2(12.24,48.82) v2(12.75,42.95) v2(12.93,80.8) v2(13.13,65) v2(13.51,83.87) v2(13.56,42.95) v2(13.76,13.26) v2(13.76,12.42) v2(13.76,11.61) v2(13.79,10.9) v2(14.35,65) v2(14.3,44.3) v2(14.4,80.75) v2(14.47,42.95) v2(14.6,63.3) v2(14.63,10.9) v2(14.7,61.65) v2(14.73,49.51) v2(14.68,48.97) v2(14.83,51.97) v2(14.75,35.51) v2(15.03,10.06) v2(15.06,60.07) v2(15.06,15.85) v2(15.06,9.27) v2(15.19,54.84) v2(15.16,42.04) v2(15.29,58.17) v2(15.29,52.5) v2(15.49,30.81) v2(15.59,29.9) v2(15.64,23.27) v2(15.62,19.99) v2(15.72,42.95) v2(15.67,14.35) v2(15.82,35.46) v2(15.85,33.55) v2(15.85,27.56) v2(15.92,11.84) v2(16.02,80.54) v2(15.97,65.1) v2(16,41.96) v2(16.18,0.74) v2(16.35,47.8) v2(16.81,35.46) v2(16.94,36.55) v2(16.94,0.74) v2(17.04,84.58) v2(16.96,41.23) v2(17.01,39.68) v2(16.96,38.66) v2(16.96,37.62) v2(17.01,3.66) v2(17.01,2.62) v2(16.99,1.58) v2(17.09,79.99) v2(17.22,82.83) v2(17.24,59.97) v2(17.22,45.14) v2(17.17,16.44) v2(17.34,46.74) v2(17.37,80.34) v2(17.42,25.38) v2(17.73,9.68) v2(17.78,24.74) v2(17.9,44.53) v2(17.85,30.43) v2(17.88,13.74) v2(18.03,40.69) v2(17.98,20.22) v2(18.11,64.82) v2(18.06,60.89) v2(18.21,56.03) v2(18.26,63.32) v2(18.34,36.73) v2(18.44,43.64) v2(18.56,38.36) v2(18.79,23.52) v2(18.77,12.02) v2(18.95,85.24) v2(18.89,82.73) v2(18.87,34.47) v2(18.87,32.28) v2(18.89,19.92) v2(19.12,17.02) v2(19.22,44.68) v2(19.22,42.83) v2(19.3,28.68) v2(19.48,64.82) v2(19.63,37.24) v2(19.66,27.61) v2(19.88,81.66) v2(20.06,62.82) v2(20.27,43.79) v2(20.62,36.6) v2(20.62,33.83) v2(20.8,43.13) v2(20.9,58.9) v2(20.85,31.83) v2(20.93,30.46) v2(21.03,64.97) v2(21.05,81.92) v2(21.13,63.55) v2(21.13,35.18) v2(21.23,37.29) v2(21.18,12.57) v2(21.41,24.31) v2(21.46,25.58) v2(21.61,41.81) v2(21.76,64.7) v2(22.22,25.35) v2(22.17,14.35) v2(22.42,83.29) v2(22.37,30.51) v2(22.55,40.57) v2(22.58,27.61) v2(22.68,26.72) v2(22.73,15.19) v2(22.86,65.2) v2(22.86,10.82) v2(23.09,74.91) v2(23.06,73.84) v2(23.06,41.84) v2(23.11,30.81) v2(23.06,24.23) v2(23.8,62.51) v2(23.92,12.02) v2(23.97,82.98) v2(24.08,81.84) v2(24.05,57.89) v2(24.15,52.33) v2(24.86,38.33) v2(25.02,7.6) v2(25.3,31.04) v2(25.45,34.62) v2(25.52,36.48) v2(25.68,12.02) v2(25.73,5.34) v2(25.83,32.21) v2(26.06,43.97) v2(26.16,33.61) v2(26.46,83.34) v2(26.64,50.32) v2(26.59,40.03) v2(26.69,49.3) v2(26.72,38.81) v2(26.79,48.03) v2(27.1,82.2) v2(27.1,9.68) v2(27.3,24.82) v2(27.28,8.08) v2(27.35,29.54) v2(27.4,27.26) v2(27.53,73.31) v2(27.63,71.81) v2(27.61,34.55) v2(27.89,83.77) v2(27.91,38.3) v2(27.86,19.48) v2(27.96,28.3) v2(28.04,18.75) v2(28.09,34.04) v2(28.06,30.23) v2(28.19,25.17) v2(28.24,21.16) v2(28.34,13.64) v2(28.42,41.71) v2(28.62,57.23) v2(28.8,82.4) v2(28.85,43.84) v2(29.03,48.97) v2(29.11,53.24) v2(29.08,5.36) v2(29.71,81.41) v2(29.71,76.18) v2(30.07,58.73) v2(30.15,22.79) v2(30.2,61.52) v2(30.2,39.98) v2(30.2,30.48) v2(30.35,25.91) v2(30.5,83.11) v2(30.45,78.28) v2(30.48,12.8) v2(30.6,43.84) v2(30.71,50.42) v2(30.68,41.02) v2(30.68,30.28) v2(30.81,37.57) v2(30.81,7.47) v2(30.88,29.57) v2(30.93,26.75) v2(30.86,21.39) v2(30.88,18.8) v2(31.11,35.31) v2(31.31,62.97) v2(31.42,67.87) v2(31.72,59.74) v2(31.72,5.44) v2(31.8,22.23) v2(32.13,36.98) v2(32.23,41.96) v2(32.31,76.33) v2(32.25,38.99) v2(32.53,53.06) v2(32.53,35.51) v2(32.69,44.02) v2(32.69,12.75) v2(32.81,38.36) v2(32.86,11.61) v2(32.92,10.54) v2(32.99,61.75) v2(33.02,25.93) v2(33.12,50.4) v2(33.25,37.11) v2(33.22,27.18) v2(33.37,80.42) v2(33.47,43.13) v2(33.64,39.02) v2(33.64,38.13) v2(33.93,20.45) v2(33.85,18.21) v2(34.11,40.69) v2(34.31,49.07) v2(34.49,81.54) v2(34.46,63.17) v2(34.54,12.75) v2(34.64,58.17) v2(34.62,29.85) v2(34.62,10.31) v2(34.57,6.81) v2(34.72,59.97) v2(34.74,50.17) v2(34.72,39.83) v2(34.81,37.11) v2(35.02,41.61) v2(35.02,34.62) v2(35.12,78.18) v2(35.07,36.55) v2(35.56,35.84) v2(35.58,12.61) v2(35.68,53.87) v2(35.71,38.93) v2(35.84,34.57) v2(35.94,39.63) v2(35.99,58.65) v2(35.99,9.73) v2(36.14,70.84) v2(36.24,68.35) v2(36.24,61.14) v2(36.34,31.07) v2(36.27,5.95) v2(36.39,76.28) v2(36.55,46.89) v2(36.47,34.4) v2(36.62,50.4) v2(36.6,38.93) v2(36.7,48.39) v2(36.75,66.09) v2(36.78,55.42) v2(36.93,39.55) v2(36.9,36.4) v2(36.93,14.35) v2(36.88,10.75) v2(37.08,66.91) v2(37.11,57.41) v2(37.08,53.09) v2(37.06,35.51) v2(37.16,63.3) v2(37.18,7.82) v2(37.31,69.19) v2(37.39,62) v2(37.44,10.62) v2(37.54,78.56) v2(37.49,71.78) v2(37.49,38.93) v2(37.87,35.71) v2(38.07,76.13) v2(38.2,58.65) v2(38.22,17.71) v2(38.38,70.59) v2(38.48,56.19) v2(38.45,10.64) v2(38.6,27.76) v2(38.78,72.72) v2(39.04,68.35) v2(38.99,60.76) v2(39.04,44.35) v2(39.14,76.43) v2(39.14,74.73) v2(39.14,66.93) v2(39.27,68.95) v2(39.27,58.8) v2(39.27,54.85) v2(39.32,54.18) v2(39.27,53.01) v2(39.39,76.2) v2(39.39,74.47) v2(39.42,70.66) v2(39.47,81.59) v2(39.54,23.55) v2(39.65,44.3) v2(39.57,11.1) v2(39.65,4.22) v2(39.62,2.69) v2(39.62,1.47) v2(39.62,0.71) v2(39.7,57.43) v2(39.82,83.67) v2(39.85,59.16) v2(39.98,78.28) v2(40.03,74.73) v2(39.98,69.6) v2(40.03,56.41) v2(39.98,35.21) v2(40.03,34.44) v2(40.15,54.87) v2(40.23,54.05) v2(40.23,49.66) v2(40.28,74.5) v2(40.33,68.05) v2(40.26,52.22) v2(40.31,42.95) v2(40.46,81.08) v2(40.46,73.05) v2(40.61,43.51) v2(40.56,36.12) v2(40.76,13.77) v2(41.07,12.68) v2(41.3,48.13) v2(41.32,42.5) v2(41.42,66.45) v2(41.45,38.13) v2(41.63,67.21) v2(41.81,78.26) v2(41.81,75.44) v2(41.78,73.08) v2(41.75,54.08) v2(41.81,51.03) v2(41.75,7.7) v2(41.93,73.77) v2(41.91,69.01) v2(41.93,55.68) v2(42.14,77.07) v2(42.08,29.87) v2(42.16,34.88) v2(42.31,75.46) v2(42.31,62.89) v2(42.31,48.19) v2(42.44,43.79) v2(42.47,66.42) v2(42.47,42.01) v2(42.62,73.64) v2(42.59,63.3) v2(42.57,52.07) v2(42.74,83.19) v2(42.74,36.86) v2(42.82,65.81) v2(42.92,63.25) v2(42.9,62.92) v2(42.9,44.2) v2(43.05,67.08) v2(43.41,81.05) v2(43.43,49.05) v2(43.48,42.44) v2(43.56,78.51) v2(43.91,75.44) v2(43.96,23.62) v2(44.14,59.21) v2(44.24,67.57) v2(44.19,61.9) v2(44.32,72.54) v2(44.29,66.02) v2(44.32,64.09) v2(44.35,62.89) v2(44.42,73.74) v2(44.37,48.16) v2(44.55,78.13) v2(44.5,49.73) v2(44.5,13.34) v2(45.08,65.3) v2(45.07,64.42) v2(45.07,63.53) v2(45.13,42.19) v2(45.21,83.85) v2(45.23,81.38) v2(45.64,48.21) v2(45.74,83.01) v2(45.72,23.8) v2(45.72,23.01) v2(45.69,21.95) v2(45.67,20.19) v2(45.67,19.36) v2(45.67,18.31) v2(45.77,48.97) v2(45.92,81.87) v2(45.92,37.44) v2(46.2,38.1) v2(46.28,66.07) v2(46.38,81.43) v2(46.55,33.15) v2(46.91,58.5) v2(46.96,36.96) v2(47.06,56.82) v2(47.39,38) v2(47.57,33.15) v2(47.75,57.63) v2(47.75,55.68) v2(47.82,59.89) v2(47.85,68.97) v2(47.85,66.54) v2(48.01,60.86) v2(48.03,46.89) v2(48.05,83.21) v2(48.21,75.03) v2(48.23,37.75) v2(48.28,79.14) v2(48.28,78.64) v2(48.54,68.97) v2(48.54,36.98) v2(48.59,33.15) v2(48.66,64.12) v2(48.8,82.2) v2(49.25,66.44) v2(49.3,69.61) v2(49.3,63.64) v2(49.3,61.86) v2(49.48,83.29) v2(49.57,40.09) v2(49.6,33.15) v2(49.98,59.29) v2(50.06,69.61) v2(50.06,61.86) v2(50.5,82.4) v2(50.62,33.15) v2(50.91,68.61) v2(51.2,38.51) v2(51.58,57.91) v2(51.63,33.15) v2(51.74,75.13) v2(51.74,73.76) v2(51.82,67.34) v2(51.82,66.7) v2(52.09,68.11) v2(52.07,57.38) v2(52.09,38.51) v2(52.19,77.5) v2(52.42,65.39) v2(52.4,55.63) v2(52.47,57.89) v2(52.65,33.15) v2(52.84,61.49) v2(52.78,55.32) v2(52.98,38.51) v2(53.13,56.06) v2(53.36,68.11) v2(53.36,57.89) v2(53.55,67.36) v2(53.66,65.69) v2(53.67,33.15) v2(53.76,64.54) v2(53.76,63.65) v2(53.76,62.38) v2(53.87,69.89) v2(53.9,57.43) v2(53.87,38.51) v2(54.07,58.14) v2(54.61,55.83) v2(54.68,33.15) v2(54.76,57.89) v2(54.94,67.68) v2(55,70.38) v2(55,69.62) v2(55.14,61.64) v2(55.14,57.38) v2(55.15,60.73) v2(55.15,59.97) v2(55.27,55.32) v2(55.38,64.57) v2(55.72,69.48) v2(55.7,67.68) v2(55.75,55.88) v2(55.7,33.15) v2(55.9,62.62) v2(56.22,75.5) v2(56.27,66.19) v2(56.41,64.02) v2(56.71,33.15) v2(56.84,57.1) v2(57.17,58.32) v2(57.71,58.98) v2(57.73,33.15) v2(57.93,72.26) v2(58.1,67.34) v2(58.11,66.19) v2(58.11,65.3) v2(58.09,64.42) v2(58.09,63.53) v2(58.11,58.68) v2(58.42,62.18) v2(58.49,71.02) v2(58.62,73.4) v2(58.57,58.37) v2(58.75,33.15) v2(58.9,62.18) v2(59,76.76) v2(59.03,51) v2(59.1,71.45) v2(59.23,52.35) v2(59.38,78.16) v2(59.7,60.22) v2(59.7,59.59) v2(59.84,69.75) v2(59.76,33.15) v2(59.97,58.37) v2(60.37,76.71) v2(60.4,60.68) v2(60.5,53.93) v2(60.68,62.87) v2(60.78,33.15) v2(60.91,63.78) v2(61.24,58.42) v2(61.29,78.31) v2(61.42,73.4) v2(61.52,57.18) v2(61.79,33.15) v2(61.95,76.76) v2(62,78.77) v2(62.13,71.27) v2(62.81,33.15) v2(63.13,71.27) v2(63.45,81.23) v2(63.52,72.09) v2(63.65,84.1) v2(63.83,33.15) v2(64.03,47.07) v2(64.23,82.3) v2(64.64,84.51) v2(64.64,81) v2(64.62,73.4) v2(64.69,71.5) v2(64.82,79.1) v2(64.84,33.15) v2(64.92,83.42) v2(65.25,47.78) v2(65.22,38.89) v2(65.48,75.59) v2(65.67,73.54) v2(65.91,83.11) v2(65.86,33.15) v2(66.21,82.32) v2(66.21,81.43) v2(66.27,53.09) v2(66.7,84.94) v2(66.82,45.62) v2(66.87,33.15) v2(67.1,84.2) v2(67.13,43.84) v2(67.18,73.99) v2(67.33,77.12) v2(67.76,81.46) v2(67.89,33.15) v2(68.04,78.01) v2(68.02,71.45) v2(68.07,47.78) v2(68.17,83.01) v2(68.55,81.69) v2(68.55,81.18) v2(68.81,84.38) v2(68.83,48.03) v2(68.91,33.15) v2(69.24,53.54) v2(69.44,54.51) v2(69.36,43.33) v2(69.95,81.08) v2(69.92,33.15) v2(69.97,53.44) v2(70.1,82.45) v2(70.3,55.83) v2(70.35,41.2) v2(70.48,84.81) v2(70.63,76.86) v2(70.74,66.6) v2(70.81,64.64) v2(70.81,63.25) v2(70.76,61.75) v2(70.84,58.68) v2(70.76,57.18) v2(70.81,54.56) v2(70.89,60.48) v2(70.94,52.12) v2(70.94,33.15) v2(70.96,79.43) v2(71.37,51.3) v2(71.65,76.86) v2(71.57,56.72) v2(71.75,80.67) v2(71.75,71.93) v2(71.93,52.86) v2(72.03,81.61) v2(71.95,59.31) v2(71.95,33.15) v2(72.11,67.74) v2(72.13,58.14) v2(72.16,62.21) v2(72.31,63.55) v2(72.39,79.53) v2(72.56,66.57) v2(72.59,61.24) v2(72.67,76.86) v2(72.84,64.8) v2(72.77,59.77) v2(73,38.89) v2(72.97,33.15) v2(73.2,80.98) v2(73.18,68.23) v2(73.41,50) v2(73.63,62.13) v2(73.63,33.15) v2(73.68,76.86) v2(73.68,68.23) v2(73.66,63.6) v2(73.8,55.91) v2(73.81,53.24) v2(73.94,65.38) v2(74.11,66.6) v2(74.65,33.15) v2(74.7,80.67) v2(74.75,79.43) v2(74.7,76.86) v2(74.7,64.81) v2(75.1,63.4) v2(75.21,66.65) v2(75.16,53.62) v2(75.26,67.64) v2(75.69,81.05) v2(75.71,76.86) v2(75.66,33.15) v2(75.9,83.07) v2(76.53,80.75) v2(76.53,58.19) v2(76.53,57.38) v2(76.63,55.68) v2(76.6,54.89) v2(76.73,76.86) v2(76.68,33.15) v2(76.83,64.8) v2(77.09,55.65) v2(77.06,54.87) v2(77.24,61.19) v2(77.37,79.43) v2(77.57,68.23) v2(77.75,76.86) v2(77.7,33.15) v2(77.95,81.36) v2(78.03,75.85) v2(77.97,74.88) v2(78.25,76.99) v2(78.71,33.15) v2(78.76,77.84) v2(79.02,80.88) v2(79.02,67.9) v2(79.22,76.76) v2(79.3,85.04) v2(79.65,77.84) v2(79.73,33.15) v2(79.8,82.7) v2(79.91,79.25) v2(79.96,76) v2(80.01,74.7) v2(80.16,60.53) v2(80.26,77.24) v2(80.54,77.84) v2(80.74,80.6) v2(80.73,75.74) v2(80.74,61.24) v2(80.74,33.15) v2(80.77,63.12) v2(81.05,73.94) v2(81.18,84.3) v2(81.3,82.96) v2(81.43,79.45) v2(81.43,77.84) v2(81.71,60.56) v2(81.76,33.15) v2(81.94,76.43) v2(81.94,75.31) v2(81.96,77.6) v2(82.06,81.54) v2(82.19,66.47) v2(82.19,57.66) v2(82.37,70.93) v2(82.42,63.58) v2(82.42,57.3) v2(82.65,85.02) v2(82.57,66.5) v2(82.7,65.36) v2(82.78,33.15) v2(83,79.05) v2(82.97,62.76) v2(83.11,73.92) v2(83.23,82.88) v2(83.26,76.13) v2(83.26,54.89) v2(83.41,76.94) v2(83.46,60.3) v2(83.59,64.49) v2(83.79,33.15) v2(83.92,63.65) v2(84.12,79.83) v2(84.11,70) v2(84.17,56.41) v2(84.3,59.46) v2(84.48,64.64) v2(84.45,62.51) v2(84.46,45.74) v2(84.63,80.75) v2(84.6,42.97) v2(84.71,82.86) v2(84.71,78.89) v2(84.83,76.73) v2(84.81,33.15) v2(84.91,81.28) v2(84.88,78.26) v2(84.91,77.42) v2(85.01,67.24) v2(85.04,54.89) v2(85.14,74.04) v2(85.16,69.51) v2(85.62,75.34) v2(85.75,64.75) v2(85.77,83.92) v2(85.85,69.24) v2(85.82,33.15) v2(86.05,74.35) v2(86.38,74.73) v2(86.64,41.67) v2(86.81,54.89) v2(86.84,33.15) v2(86.92,83.57) v2(87.12,74.83) v2(87.32,59.08) v2(87.4,33.55) v2(87.86,33.15) v2(88.03,75.59) v2(88.19,65.3) v2(88.19,64.42) v2(88.21,63.53) v2(88.24,60.76) v2(88.34,82.86) v2(88.44,67.26) v2(88.41,34.82) v2(88.54,33.81) v2(88.57,54.89) v2(88.82,83.72) v2(88.9,64.37) v2(88.87,33.15) v2(89.3,57.14) v2(89.38,34.95) v2(89.43,33.81) v2(89.56,64.31) v2(89.58,59.69) v2(89.94,62.66) v2(89.89,33.15) v2(90.01,40.16) v2(90.12,67.34) v2(90.09,42.98) v2(90.52,83.24) v2(90.52,41.23) v2(90.5,38.71) v2(90.57,33.81) v2(90.75,37.11) v2(90.9,33.15) v2(91,84) v2(91.11,64.14) v2(91.21,35.42) v2(91.26,62.43) v2(91.31,44.45) v2(91.26,38.79) v2(91.59,46.86) v2(91.72,33.81) v2(91.92,33.15) v2(92.05,69.37) v2(92.05,68.48) v2(92.05,66.7) v2(92.05,65.81) v2(92.05,64.92) v2(92,36.2) v2(92.1,83.62) v2(92.12,83.01) v2(92.07,71.15) v2(92.07,70.26) v2(92.06,67.59) v2(92.38,44.43) v2(92.48,46.86) v2(92.63,49.81) v2(92.73,33.81) v2(92.83,35.46) v2(92.94,33.15) v2(93.21,51.87) v2(93.52,73.46) v2(93.49,57.3) v2(93.65,62.23) v2(93.75,33.81) v2(93.93,84.86) v2(93.88,64.16) v2(93.95,62.92) v2(93.95,33.15) v2(94.05,82.68) v2(94.69,73.41) v2(94.76,33.81) v2(94.89,86.06) v2(94.97,33.15) v2(95.17,46.86) v2(95.43,75.1) v2(95.4,35.31) v2(95.53,60.57) v2(95.48,59.82) v2(95.58,75.57) v2(95.81,59.49) v2(95.91,33.81) v2(95.98,33.15) v2(96.21,59.56) v2(96.16,46.76) v2(96.64,35.33) v2(96.75,75.52) v2(96.69,59.95) v2(96.9,74.3) v2(96.89,37.67) v2(96.97,59.39) v2(97,33.15) v2(97.05,33.81) v2(97.43,49.9) v2(97.56,35.28) v2(98.02,33.15) v2(98.07,33.81) v2(98.19,60.59) v2(98.45,35.28) v2(98.6,38.84) v2(98.7,47.04) v2(98.99,73.51) v2(99.03,33.15) v2(99.21,33.81) v2(99.29,37.7) v2(99.34,35.28) v2(99.36,38.79) v2(99.59,47.04) v2(100.05,33.15) v2(100.23,44.77) v2(100.23,42.98) v2(100.23,33.81) v2(100.28,38.53) v2(100.35,37.19) v2(100.73,38.76) v2(100.81,59.92) v2(101,75.21) v2(101.09,52.25) v2(101.09,50.88) v2(101.06,33.15) v2(101.22,85.47) v2(101.22,54.94) v2(101.19,36.17) v2(101.34,42.65) v2(101.37,33.81) v2(101.5,81.31) v2(101.5,37.24) v2(101.65,51.61) v2(101.83,84.3) v2(101.8,40.9) v2(101.9,60.12) v2(102,62.3) v2(102.08,50.7) v2(102.08,33.15) v2(102.21,40.9) v2(102.38,36.86) v2(102.46,54.15) v2(102.51,33.81) v2(102.71,82.53) v2(102.69,55.88) v2(102.65,44.48) v2(102.66,40.9) v2(103.02,77.34) v2(103.1,33.15) v2(103.27,85.24) v2(103.55,45.06) v2(103.55,44.6) v2(103.55,44.15) v2(103.6,39.35) v2(103.63,34.85) v2(103.76,77.34) v2(103.78,33.81) v2(104.09,50.95) v2(104.39,83.57) v2(104.37,45.39) v2(104.52,44.2) v2(104.72,42.65) v2(104.8,78.16) v2(104.9,81.92) v2(104.95,39.35) v2(104.9,38.28) v2(104.92,37.24) v2(104.92,36.22) v2(104.92,35.08) v2(104.92,33.94) v2(105.23,52.05) v2(105.31,83.62) v2(105.31,46.13) v2(105.89,54.36) v2(106.09,55.81) v2(106.09,47.35) v2(106.19,34.14) v2(106.32,39.07) v2(106.55,85.45) v2(106.6,84.51) v2(106.8,81.69) v2(106.8,74.83) v2(106.98,55.93) v2(107.21,48.29) v2(107.34,46.61) v2(107.64,72.75) v2(107.74,68.35) v2(107.72,44.53) v2(107.67,42.17) v2(107.79,70.92) v2(107.77,47.37) v2(107.88,73.14) v2(108.02,69.57) v2(108.28,71.88) v2(108.29,70.72) v2(108.4,64.03) v2(108.48,66.07) v2(108.48,60.53) v2(108.51,58.5) v2(108.53,48.34) v2(108.61,53.77) v2(108.58,49.99) v2(109.14,46.25) v2(109.22,44.58) v2(109.34,85.45) v2(109.45,71.02) v2(109.42,66.55) v2(109.39,54.64) v2(109.45,50.4) v2(109.5,59.49) v2(109.5,43.28) v2(109.6,65.76) v2(109.73,72.02) v2(109.83,72.54) v2(110.03,60.38) v2(110.18,61.7) v2(110.16,55.58) v2(110.41,62.18) v2(110.41,53.11) v2(110.51,68.81) v2(110.69,46.23) v2(110.77,68.28) v2(110.84,60.89) v2(110.84,59.92) v2(110.78,56.03) v2(111.12,41.89) v2(111.32,43.23) v2(111.4,68.81) v2(111.35,53.19) v2(111.5,68.25) v2(111.71,67.62) v2(111.66,52.39) v2(111.78,73.31) v2(111.81,66.45) v2(111.81,65.3) v2(111.82,44.22) v2(112.61,72.34) v2(112.59,71.96) v2(112.6,71.54) v2(112.75,48.59) v2(112.72,38.74) v2(112.8,74.91) v2(113.02,75.5) v2(113.15,68.84) v2(113.23,44.63) v2(113.18,41.84) v2(113.31,43.16) v2(113.86,45.77) v2(113.94,43.08) v2(114.07,68.81) v2(114.14,36.73) v2(114.12,34.65) v2(114.27,66.57) v2(114.55,50.88) v2(114.73,55.07) v2(114.68,38.79) v2(114.83,55.4) v2(114.88,41.78) v2(114.96,68.81) v2(115.16,45.77) v2(115.41,51.03) v2(115.6,59.34) v2(115.59,54.97) v2(115.59,48.85) v2(115.59,46.2) v2(115.69,45.24) v2(115.85,68.81) v2(116.13,73.41) v2(116.1,66.63) v2(116.23,37.21) v2(116.33,42.14) v2(116.3,35.13) v2(116.48,54.97) v2(116.6,59.84) v2(116.79,54.18) v2(117.12,51.89) v2(117.24,43.21) v2(117.55,73.53) v2(117.62,68.82) v2(117.6,57.84) v2(117.62,54.97) v2(117.8,38.71) v2(117.85,34.37) v2(118.13,43.21) v2(118.11,36.37) v2(118.21,55.68) v2(118.21,54.87) v2(118.44,70.26) v2(118.39,46.76) v2(118.46,66.65) v2(118.64,72.75) v2(118.64,71.81) v2(118.74,65.69) v2(118.78,70.64) v2(118.89,46.76) v2(119.02,43.21) v2(119.2,73.41) v2(119.33,69.6) v2(119.3,68.2) v2(119.44,71.86) v2(119.68,63.86) v2(119.83,71.05) v2(120.14,72.11) v2(120.29,79.25) v2(120.34,76.58) v2(120.29,37.39) v2(120.32,34.8) v2(120.37,75.41) v2(120.55,67.59) v2(120.72,65.38) v2(120.8,43.18) v2(120.93,66.57) v2(120.98,60.61) v2(120.95,59.92) v2(120.95,59.18) v2(121.13,81.66) v2(121.13,75.41) v2(121.26,84.76) v2(121.33,64.24) v2(121.41,59.31) v2(121.46,78.36) v2(121.61,76.46) v2(121.82,68.1) v2(121.94,59.23) v2(122.07,69.62) v2(122.17,39.04) v2(122.25,37.49) v2(122.42,62.49) v2(122.48,34.85) v2(122.65,67.69) v2(123.03,40.79) v2(123.09,79.22) v2(123.34,78.51) v2(123.42,60.28) v2(123.39,54.76) v2(123.42,53.77) v2(123.44,52.86) v2(123.44,52) v2(123.44,51.03) v2(123.44,50.06) v2(123.44,49.23) v2(123.44,48.31) v2(123.44,47.45) v2(123.42,46.41) v2(123.42,45.21) v2(123.42,44.07) v2(123.42,43.05) v2(123.42,42.06) v2(123.42,41.28) v2(123.47,65.81) v2(123.49,64.03) v2(123.47,62.28) v2(123.47,59.44) v2(123.47,57.81) v2(123.47,56.67) v2(123.69,84.69) v2(124.1,68.23) v2(124.46,64.44) v2(124.48,62.33) v2(124.69,56.47) v2(124.79,66.57) v2(124.86,65.97) v2(125.09,79.94) v2(125.09,57.33) v2(125.47,84.74) v2(125.65,79.58) v2(126.16,56.87) v2(126.31,79.1) v2(126.31,68.18) v2(126.41,78.23) v2(126.64,75.34) v2(126.56,73.56) v2(126.72,77.57) v2(126.67,71.58) v2(126.82,74.32) v2(127.05,79.07) v2(127,65.99) v2(126.97,59.16) v2(127.1,73.56) v2(127.17,70.26) v2(127.71,79.38) v2(127.78,70.26) v2(128.06,78.36) v2(128.09,71.81) v2(128.22,73.84) v2(128.75,84.76) v2(128.72,55.3) v2(128.8,64.39) v2(128.8,63.45) v2(128.8,62.64) v2(128.8,61.95) v2(128.8,60.89) v2(128.8,59.54) v2(128.8,58.22) v2(128.8,56.82) v2(129.31,85.45) v2(129.44,74.83) v2(129.41,71.81) v2(129.49,79.25) v2(130.04,77.37) v2(130.53,72.62) v2(130.73,70.28) v2(130.76,79.33) v2(130.91,74.17) v2(130.91,71.76) v2(131.21,67.26) v2(131.37,85.12) v2(131.47,70.11) v2(132.23,76.96) v2(132.18,67.36) v2(132.36,70.11) v2(132.76,78.31) v2(133.02,85.32) v2(132.97,79.35) v2(133.02,74.25) v2(133.25,70.08) v2(133.63,67.34) v2(133.65,75.34) v2(134.16,70.08) v2(134.54,84.53) v2(134.54,77.19) v2(134.9,74.32) v2(135,70.11) v2(135.63,83.85) v2(135.79,70.51) v2(135.91,82.78) v2(135.91,72.9) v2(135.91,72.37) v2(136.27,70.16) v2(136.42,85.17) v2(136.62,75.69) v2(136.8,70.08) v2(137,74.5) v2(137.36,82.04) v2(137.69,70.09) v2(137.82,80.88) v2(137.89,82.91) v2(138.02,67.57) v2(138.25,74.04) v2(138.2,71.65) v2(138.5,81.41) v2(138.58,83.95) v2(138.55,70.38) v2(139.04,67.57) v2(139.26,81.28) v2(139.47,85.04) v2(139.77,82.5) v2(140.05,67.57) v2(140.23,73.56) v2(140.28,81.1) v2(140.33,73.05) v2(140.33,72.67) v2(140.61,80.82) v2(140.87,70.61) v2(141.07,67.57) v2(141.21,72.96) v2(141.75,81.92) v2(141.93,82.35) v2(142.01,71.93) v2(142.08,67.57) v2(142.24,84.53) v2(142.29,86.29) v2(142.44,82.81) v2(142.39,73.74) v2(142.69,85.32) v2(143.07,70.59) v2(143.1,67.57) v2(143.25,86.29) v2(143.83,72.14) v2(144.12,67.57) v2(144.19,86.29) v2(144.17,85.6) v2(144.19,70.69) v2(144.98,73.51) v2(145.13,67.57) v2(145.21,86.29) v2(145.92,85.37) v2(145.95,70.72) v2(146.15,67.57) v2(146.22,86.29) v2(147.24,86.29) v2(147.16,67.57) v2(147.37,71.15) v2(147.77,85.55) v2(148.18,67.57) v2(148.26,86.29) v2(148.74,78.89) v2(149.2,67.57) v2(149.27,86.29) v2(149.76,78.89) v2(150.29,86.29) v2(150.57,85.55) v2(150.77,84.99) v2(150.9,78.13) v2(151.3,86.29) v2(151.28,76.73) v2(151.79,73.43) v2(151.91,81.56) v2(151.91,68.73) v2(151.99,67.34) v2(152.32,86.29) v2(152.7,68.81) v2(152.93,85.68) v2(153.21,68.61) v2(153.34,86.29) v2(153.36,69.75) v2(153.59,67.31) v2(153.82,68.84) v2(153.91,82.81) v2(153.91,81.79) v2(154.25,86.29) v2(154.38,68.61) v2(154.62,72.14) v2(154.75,79.88) v2(154.71,79) v2(154.71,78.11) v2(154.84,68.85) v2(155.04,67.26) v2(155.52,68.56) v2(156.18,84.94) v2(156.49,74.68) v2(156.61,69.34) v2(156.74,84.35) v2(157.02,67.95) v2(157.12,77.89) v2(157.96,69.93) v2(158.05,68.99) v2(158.14,67.41) v2(158.77,77.89) v2(159.1,84.18) v2(159.46,67.92) v2(159.75,77.6) v2(159.75,76.71) v2(160.18,79.25) v2(160.37,67.36) v2(160.5,84.71) v2(161.01,84.18) v2(161.49,84.71) v2(161.57,79) v2(161.62,68) v2(161.95,84.23) v2(162.25,84.71) v2(162.46,79) v2(162.48,67.36) v2(163.09,84.76) v2(163.37,84.18) v2(164.02,73.53) v2(164.16,84.76) v2(164.36,78.53) v2(164.87,84.1) v3(0.81,42.8) v3(1.42,45.37) v3(1.93,69.93) v3(1.9,67.24) v3(1.93,64.77) v3(1.98,43.66) v3(2.05,73.28) v3(2.13,47.96) v3(2.18,47.27) v3(2.54,62.94) v3(2.84,71.78) v3(2.92,64.26) v3(2.94,42.72) v3(3.07,74.83) v3(3.2,43.36) v3(3.32,75.82) v3(3.35,68.4) v3(3.6,48.19) v3(3.68,49.86) v3(3.73,49.4) v3(3.91,65.21) v3(4.11,63.51) v3(4.16,42.42) v3(4.34,49.84) v3(4.34,46.41) v3(4.37,43.38) v3(4.59,73.69) v3(4.7,49.05) v3(4.85,72.92) v3(4.82,71.73) v3(4.95,70.74) v3(4.95,65.69) v3(4.9,62.51) v3(5.03,49.86) v3(5.08,64.11) v3(5.1,43.03) v3(5.23,75.24) v3(5.2,69.32) v3(5.38,48.36) v3(5.53,47.17) v3(5.71,49.84) v3(5.81,70.59) v3(6.19,72.82) v3(6.3,74.12) v3(6.37,69.7) v3(6.41,64.67) v3(6.45,49.84) v3(6.85,48.39) v3(6.91,43.03) v3(6.96,68.58) v3(6.99,67.91) v3(7.21,49.84) v3(7.29,46.33) v3(7.36,72.67) v3(7.36,70.69) v3(7.82,48.34) v3(7.95,49.84) v3(8.02,69.32) v3(8.38,68.43) v3(8.38,46.92) v3(8.71,49.84) v3(8.99,70.87) v3(9.06,74.17) v3(9.22,46.97) v3(9.39,48.67) v3(9.52,75.34) v3(9.52,49.81) v3(9.57,67.21) v3(9.62,63.43) v3(9.75,82.83) v3(9.75,65.48) v3(9.75,43.08) v3(10.31,78.28) v3(10.31,72.47) v3(10.28,49.79) v3(10.35,45.24) v3(10.41,76.28) v3(10.36,69.19) v3(10.46,77.17) v3(10.49,70.72) v3(10.46,67.34) v3(10.46,44.22) v3(10.61,78.94) v3(10.59,73.46) v3(10.64,66.19) v3(10.66,74.55) v3(10.92,42.95) v3(11.1,48.52) v3(11.3,49.76) v3(11.38,74.73) v3(11.38,47.32) v3(11.5,65.46) v3(11.45,63.37) v3(11.45,42.95) v3(11.55,44.58) v3(11.68,82.12) v3(11.83,80.6) v3(11.91,63.91) v3(11.88,49.76) v3(12.14,60.33) v3(12.14,59.31) v3(12.14,58.29) v3(12.14,57.28) v3(12.14,56.26) v3(12.14,55.25) v3(12.14,54.23) v3(12.14,53.21) v3(12.14,52.2) v3(12.14,51.18) v3(12.14,50.17) v3(12.24,48.82) v3(12.75,42.95) v3(12.93,80.8) v3(13.13,65) v3(13.51,83.87) v3(13.56,42.95) v3(13.76,13.26) v3(13.76,12.42) v3(13.76,11.61) v3(13.79,10.9) v3(14.35,65) v3(14.3,44.3) v3(14.4,80.75) v3(14.47,42.95) v3(14.6,63.3) v3(14.63,10.9) v3(14.7,61.65) v3(14.73,49.51) v3(14.68,48.97) v3(14.83,51.97) v3(14.75,35.51) v3(15.03,10.06) v3(15.06,60.07) v3(15.06,15.85) v3(15.06,9.27) v3(15.19,54.84) v3(15.16,42.04) v3(15.29,58.17) v3(15.29,52.5) v3(15.49,30.81) v3(15.59,29.9) v3(15.64,23.27) v3(15.62,19.99) v3(15.72,42.95) v3(15.67,14.35) v3(15.82,35.46) v3(15.85,33.55) v3(15.85,27.56) v3(15.92,11.84) v3(16.02,80.54) v3(15.97,65.1) v3(16,41.96) v3(16.18,0.74) v3(16.35,47.8) v3(16.81,35.46) v3(16.94,36.55) v3(16.94,0.74) v3(17.04,84.58) v3(16.96,41.23) v3(17.01,39.68) v3(16.96,38.66) v3(16.96,37.62) v3(17.01,3.66) v3(17.01,2.62) v3(16.99,1.58) v3(17.09,79.99) v3(17.22,82.83) v3(17.24,59.97) v3(17.22,45.14) v3(17.17,16.44) v3(17.34,46.74) v3(17.37,80.34) v3(17.42,25.38) v3(17.73,9.68) v3(17.78,24.74) v3(17.9,44.53) v3(17.85,30.43) v3(17.88,13.74) v3(18.03,40.69) v3(17.98,20.22) v3(18.11,64.82) v3(18.06,60.89) v3(18.21,56.03) v3(18.26,63.32) v3(18.34,36.73) v3(18.44,43.64) v3(18.56,38.36) v3(18.79,23.52) v3(18.77,12.02) v3(18.95,85.24) v3(18.89,82.73) v3(18.87,34.47) v3(18.87,32.28) v3(18.89,19.92) v3(19.12,17.02) v3(19.22,44.68) v3(19.22,42.83) v3(19.3,28.68) v3(19.48,64.82) v3(19.63,37.24) v3(19.66,27.61) v3(19.88,81.66) v3(20.06,62.82) v3(20.27,43.79) v3(20.48,40.07) v3(20.62,36.6) v3(20.62,33.83) v3(20.8,43.13) v3(20.9,58.9) v3(20.85,31.83) v3(20.93,30.46) v3(21.03,64.97) v3(21.05,81.92) v3(21.13,63.55) v3(21.13,35.18) v3(21.23,37.29) v3(21.18,12.57) v3(21.41,24.31) v3(21.46,25.58) v3(21.61,41.81) v3(21.61,39.42) v3(21.76,64.7) v3(22.22,25.35) v3(22.17,14.35) v3(22.42,83.29) v3(22.37,30.51) v3(22.55,40.57) v3(22.58,27.61) v3(22.68,26.72) v3(22.73,15.19) v3(22.86,65.2) v3(22.86,10.82) v3(23.09,74.91) v3(23.06,73.84) v3(23.06,41.84) v3(23.11,30.81) v3(23.06,24.23) v3(23.26,39.32) v3(23.26,38.97) v3(23.26,38.61) v3(23.26,38.25) v3(23.8,62.51) v3(23.92,12.02) v3(23.97,82.98) v3(24.08,81.84) v3(24.05,57.89) v3(24.15,52.33) v3(24.18,40.44) v3(24.43,42.32) v3(24.74,42.04) v3(24.86,38.33) v3(24.96,41.66) v3(25.02,7.6) v3(25.22,41.23) v3(25.3,31.04) v3(25.37,40.84) v3(25.37,40.01) v3(25.37,39.65) v3(25.45,34.62) v3(25.52,36.48) v3(25.68,12.02) v3(25.73,5.34) v3(25.83,32.21) v3(26.06,43.97) v3(26.16,33.61) v3(26.46,83.34) v3(26.64,50.32) v3(26.59,40.03) v3(26.69,49.3) v3(26.72,38.81) v3(26.79,48.03) v3(27.1,82.2) v3(27.14,44.04) v3(27.15,43.24) v3(27.1,9.68) v3(27.3,24.82) v3(27.28,8.08) v3(27.35,29.54) v3(27.4,27.26) v3(27.53,73.31) v3(27.63,71.81) v3(27.61,34.55) v3(27.89,83.77) v3(27.91,38.3) v3(27.86,19.48) v3(27.96,28.3) v3(28.04,18.75) v3(28.09,34.04) v3(28.06,30.23) v3(28.19,25.17) v3(28.24,21.16) v3(28.34,13.64) v3(28.42,41.71) v3(28.62,57.23) v3(28.8,82.4) v3(28.85,43.84) v3(29.03,48.97) v3(29.11,53.24) v3(29.08,5.36) v3(29.71,81.41) v3(29.71,76.18) v3(29.93,42.32) v3(29.93,41.77) v3(30.07,58.73) v3(30.15,22.79) v3(30.2,61.52) v3(30.2,39.98) v3(30.2,30.48) v3(30.35,25.91) v3(30.5,83.11) v3(30.45,78.28) v3(30.48,12.8) v3(30.6,43.84) v3(30.71,50.42) v3(30.68,41.02) v3(30.68,30.28) v3(30.81,37.57) v3(30.81,7.47) v3(30.88,29.57) v3(30.93,26.75) v3(30.86,21.39) v3(30.88,18.8) v3(31.11,35.31) v3(31.31,62.97) v3(31.42,67.87) v3(31.72,59.74) v3(31.72,5.44) v3(31.8,22.23) v3(32.13,36.98) v3(32.23,41.96) v3(32.31,76.33) v3(32.25,38.99) v3(32.53,53.06) v3(32.53,35.51) v3(32.69,44.02) v3(32.69,12.75) v3(32.81,38.36) v3(32.86,11.61) v3(32.92,10.54) v3(32.99,61.75) v3(33.02,25.93) v3(33.12,50.4) v3(33.25,37.11) v3(33.22,27.18) v3(33.37,80.42) v3(33.47,43.13) v3(33.64,39.02) v3(33.64,38.13) v3(33.93,20.45) v3(33.85,18.21) v3(34.11,40.69) v3(34.31,49.07) v3(34.49,81.54) v3(34.46,63.17) v3(34.54,12.75) v3(34.64,58.17) v3(34.62,29.85) v3(34.62,10.31) v3(34.57,6.81) v3(34.72,59.97) v3(34.74,50.17) v3(34.72,39.83) v3(34.81,37.11) v3(35.02,41.61) v3(35.02,34.62) v3(35.12,78.18) v3(35.07,36.55) v3(35.56,35.84) v3(35.58,12.61) v3(35.68,53.87) v3(35.71,38.93) v3(35.84,34.57) v3(35.94,39.63) v3(35.99,58.65) v3(35.99,9.73) v3(36.14,70.84) v3(36.24,68.35) v3(36.24,61.14) v3(36.34,31.07) v3(36.27,5.95) v3(36.39,76.28) v3(36.55,46.89) v3(36.47,34.4) v3(36.62,50.4) v3(36.6,38.93) v3(36.7,48.39) v3(36.75,66.09) v3(36.78,55.42) v3(36.93,39.55) v3(36.9,36.4) v3(36.93,14.35) v3(36.88,10.75) v3(37.08,66.91) v3(37.11,57.41) v3(37.08,53.09) v3(37.06,35.51) v3(37.16,63.3) v3(37.18,7.82) v3(37.31,69.19) v3(37.39,62) v3(37.44,10.62) v3(37.54,78.56) v3(37.49,71.78) v3(37.49,38.93) v3(37.87,35.71) v3(38.07,76.13) v3(38.2,58.65) v3(38.22,17.71) v3(38.38,70.59) v3(38.48,56.19) v3(38.45,10.64) v3(38.6,27.76) v3(38.78,72.72) v3(39.04,68.35) v3(38.99,60.76) v3(39.04,44.35) v3(39.14,76.43) v3(39.14,74.73) v3(39.14,66.93) v3(39.27,68.95) v3(39.27,58.8) v3(39.27,54.85) v3(39.32,54.18) v3(39.27,53.01) v3(39.39,76.2) v3(39.39,74.47) v3(39.42,70.66) v3(39.47,81.59) v3(39.54,23.55) v3(39.65,44.3) v3(39.57,11.1) v3(39.65,4.22) v3(39.62,2.69) v3(39.62,1.47) v3(39.62,0.71) v3(39.7,57.43) v3(39.82,83.67) v3(39.85,59.16) v3(39.98,78.28) v3(40.03,74.73) v3(39.98,69.6) v3(40.03,56.41) v3(39.98,35.21) v3(40.03,34.44) v3(40.15,54.87) v3(40.23,54.05) v3(40.23,49.66) v3(40.28,74.5) v3(40.33,68.05) v3(40.26,52.22) v3(40.31,42.95) v3(40.46,81.08) v3(40.46,73.05) v3(40.61,43.51) v3(40.56,36.12) v3(40.76,13.77) v3(41.07,12.68) v3(41.3,48.13) v3(41.32,42.5) v3(41.42,66.45) v3(41.45,38.13) v3(41.63,67.21) v3(41.81,78.26) v3(41.81,75.44) v3(41.78,73.08) v3(41.75,54.08) v3(41.81,51.03) v3(41.75,7.7) v3(41.93,73.77) v3(41.91,69.01) v3(41.93,55.68) v3(42.14,77.07) v3(42.08,29.87) v3(42.16,34.88) v3(42.31,75.46) v3(42.31,62.89) v3(42.31,48.19) v3(42.44,43.79) v3(42.47,66.42) v3(42.47,42.01) v3(42.62,73.64) v3(42.59,63.3) v3(42.57,52.07) v3(42.74,83.19) v3(42.74,36.86) v3(42.82,65.81) v3(42.92,63.25) v3(42.9,62.92) v3(42.9,44.2) v3(43.05,67.08) v3(43.41,81.05) v3(43.43,49.05) v3(43.48,42.44) v3(43.56,78.51) v3(43.91,75.44) v3(43.96,23.62) v3(44.14,59.21) v3(44.24,67.57) v3(44.19,61.9) v3(44.32,72.54) v3(44.29,66.02) v3(44.32,64.09) v3(44.35,62.89) v3(44.42,73.74) v3(44.37,48.16) v3(44.55,78.13) v3(44.5,49.73) v3(44.5,13.34) v3(45.08,65.3) v3(45.07,64.42) v3(45.07,63.53) v3(45.13,42.19) v3(45.21,83.85) v3(45.23,81.38) v3(45.64,48.21) v3(45.74,83.01) v3(45.72,23.8) v3(45.72,23.01) v3(45.69,21.95) v3(45.67,20.19) v3(45.67,19.36) v3(45.67,18.31) v3(45.77,48.97) v3(45.92,81.87) v3(45.92,37.44) v3(46.2,38.1) v3(46.28,66.07) v3(46.38,81.43) v3(46.55,33.15) v3(46.91,58.5) v3(46.96,36.96) v3(47.06,56.82) v3(47.57,33.15) v3(47.75,57.63) v3(47.75,55.68) v3(47.82,59.89) v3(47.85,68.97) v3(47.85,66.54) v3(48.01,60.86) v3(48.03,46.89) v3(48.05,83.21) v3(48.21,75.03) v3(48.23,37.75) v3(48.28,79.14) v3(48.28,78.64) v3(48.54,68.97) v3(48.59,33.15) v3(48.66,64.12) v3(48.8,82.2) v3(49.25,66.44) v3(49.3,69.61) v3(49.3,63.64) v3(49.3,61.86) v3(49.48,83.29) v3(49.57,40.09) v3(49.6,33.15) v3(49.68,38) v3(49.81,36.98) v3(49.98,59.29) v3(50.06,69.61) v3(50.06,61.86) v3(50.5,82.4) v3(50.62,33.15) v3(50.91,68.61) v3(51.2,38.51) v3(51.58,57.91) v3(51.63,33.15) v3(51.74,75.13) v3(51.74,73.76) v3(51.82,67.34) v3(51.82,66.7) v3(52.09,68.11) v3(52.07,57.38) v3(52.09,38.51) v3(52.19,77.5) v3(52.42,65.39) v3(52.4,55.63) v3(52.47,57.89) v3(52.65,33.15) v3(52.84,61.49) v3(52.78,55.32) v3(52.98,38.51) v3(53.13,56.06) v3(53.36,57.89) v3(53.55,67.36) v3(53.66,65.69) v3(53.67,33.15) v3(53.76,64.54) v3(53.76,63.65) v3(53.76,62.38) v3(53.87,69.89) v3(53.9,57.43) v3(53.87,38.51) v3(54.07,58.14) v3(54.61,55.83) v3(54.68,33.15) v3(54.76,57.89) v3(54.94,67.68) v3(55,70.38) v3(55,69.62) v3(55.14,61.64) v3(55.14,57.38) v3(55.15,60.73) v3(55.15,59.97) v3(55.27,55.32) v3(55.38,64.57) v3(55.72,69.48) v3(55.7,67.68) v3(55.75,55.88) v3(55.7,33.15) v3(55.9,62.62) v3(56.22,75.5) v3(56.27,66.19) v3(56.41,64.02) v3(56.71,33.15) v3(56.84,57.1) v3(57.17,58.32) v3(57.71,58.98) v3(57.73,33.15) v3(57.91,80.27) v3(57.93,72.26) v3(58.1,67.34) v3(58.11,66.19) v3(58.11,65.3) v3(58.09,64.42) v3(58.09,63.53) v3(58.11,58.68) v3(58.42,62.18) v3(58.49,71.02) v3(58.62,73.4) v3(58.57,58.37) v3(58.75,33.15) v3(58.9,62.18) v3(59,76.76) v3(59.03,51) v3(59.1,71.45) v3(59.23,52.35) v3(59.38,78.16) v3(59.7,60.22) v3(59.7,59.59) v3(59.76,71.6) v3(59.84,69.75) v3(59.76,33.15) v3(59.97,58.37) v3(60.37,76.71) v3(60.4,60.68) v3(60.47,71.58) v3(60.5,53.93) v3(60.68,62.87) v3(60.78,33.15) v3(60.91,63.78) v3(61.24,58.42) v3(61.29,78.31) v3(61.42,73.4) v3(61.52,57.18) v3(61.79,33.15) v3(61.95,76.76) v3(62,78.77) v3(62,70.79) v3(62.13,71.27) v3(62.35,72.32) v3(62.81,33.15) v3(63.12,72.8) v3(63.13,71.27) v3(63.45,81.23) v3(63.52,72.09) v3(63.65,84.1) v3(63.83,33.15) v3(64.03,47.07) v3(64.23,82.3) v3(64.64,84.51) v3(64.64,81) v3(64.62,73.4) v3(64.69,71.5) v3(64.82,79.1) v3(64.84,33.15) v3(64.92,83.42) v3(65.25,47.78) v3(65.22,38.89) v3(65.48,75.59) v3(65.67,73.54) v3(65.91,83.11) v3(65.86,33.15) v3(66.21,82.32) v3(66.21,81.43) v3(66.27,53.09) v3(66.7,84.94) v3(66.82,45.62) v3(66.87,33.15) v3(67.1,84.2) v3(67.13,43.84) v3(67.18,73.99) v3(67.33,77.12) v3(67.76,81.46) v3(67.89,33.15) v3(68.04,78.01) v3(68.02,71.45) v3(68.07,47.78) v3(68.17,83.01) v3(68.55,81.69) v3(68.55,81.18) v3(68.81,84.38) v3(68.83,48.03) v3(68.91,33.15) v3(69.24,53.54) v3(69.44,54.51) v3(69.36,43.33) v3(69.95,81.08) v3(69.92,33.15) v3(69.97,53.44) v3(70.1,82.45) v3(70.3,55.83) v3(70.35,41.2) v3(70.48,84.81) v3(70.63,76.86) v3(70.74,66.6) v3(70.81,64.64) v3(70.81,63.25) v3(70.76,61.75) v3(70.84,58.68) v3(70.76,57.18) v3(70.81,54.56) v3(70.89,60.48) v3(70.94,52.12) v3(70.94,33.15) v3(70.96,79.43) v3(71.37,51.3) v3(71.65,76.86) v3(71.57,56.72) v3(71.75,80.67) v3(71.75,71.93) v3(71.93,52.86) v3(72.03,81.61) v3(71.95,59.31) v3(71.95,33.15) v3(72.11,67.74) v3(72.13,58.14) v3(72.16,62.21) v3(72.31,63.55) v3(72.39,79.53) v3(72.56,66.57) v3(72.59,61.24) v3(72.67,76.86) v3(72.84,64.8) v3(72.77,59.77) v3(73,38.89) v3(72.97,33.15) v3(73.2,80.98) v3(73.18,68.23) v3(73.41,50) v3(73.63,62.13) v3(73.63,33.15) v3(73.68,76.86) v3(73.68,68.23) v3(73.66,63.6) v3(73.8,55.91) v3(73.81,53.24) v3(73.9,83.76) v3(73.94,65.38) v3(74.11,66.6) v3(74.3,83.76) v3(74.65,33.15) v3(74.7,80.67) v3(74.75,79.43) v3(74.7,76.86) v3(74.7,64.81) v3(75.1,83.76) v3(75.1,63.4) v3(75.21,66.65) v3(75.16,53.62) v3(75.26,67.64) v3(75.5,83.76) v3(75.69,81.05) v3(75.71,76.86) v3(75.66,33.15) v3(75.9,83.76) v3(75.9,83.07) v3(76.53,80.75) v3(76.53,58.19) v3(76.53,57.38) v3(76.63,55.68) v3(76.6,54.89) v3(76.73,76.86) v3(76.68,33.15) v3(76.83,64.8) v3(77.09,55.65) v3(77.06,54.87) v3(77.24,61.19) v3(77.37,79.43) v3(77.57,68.23) v3(77.75,76.86) v3(77.7,33.15) v3(77.95,81.36) v3(77.95,78.03) v3(78.03,75.85) v3(77.97,74.88) v3(78.25,76.99) v3(78.71,33.15) v3(78.76,77.84) v3(79.02,80.88) v3(79.02,67.9) v3(79.22,76.76) v3(79.3,85.04) v3(79.65,77.84) v3(79.73,33.15) v3(79.8,82.7) v3(79.91,79.25) v3(79.96,76) v3(80.01,74.7) v3(80.16,60.53) v3(80.26,77.24) v3(80.54,77.84) v3(80.74,80.6) v3(80.73,75.74) v3(80.74,61.24) v3(80.74,33.15) v3(80.77,63.12) v3(81.05,73.94) v3(81.18,84.3) v3(81.3,82.96) v3(81.43,79.45) v3(81.43,77.84) v3(81.71,60.56) v3(81.76,33.15) v3(81.94,76.43) v3(81.94,75.31) v3(81.96,77.6) v3(82.06,81.54) v3(82.19,66.47) v3(82.19,57.66) v3(82.37,70.93) v3(82.42,63.58) v3(82.42,57.3) v3(82.65,85.02) v3(82.57,66.5) v3(82.7,65.36) v3(82.78,33.15) v3(83,79.05) v3(82.97,62.76) v3(83.11,73.92) v3(83.23,82.88) v3(83.26,76.13) v3(83.26,54.89) v3(83.41,76.94) v3(83.46,60.3) v3(83.59,64.49) v3(83.79,33.15) v3(83.92,63.65) v3(84.12,79.83) v3(84.11,70) v3(84.17,56.41) v3(84.3,59.46) v3(84.48,64.64) v3(84.45,62.51) v3(84.46,45.74) v3(84.63,80.75) v3(84.6,42.97) v3(84.71,82.86) v3(84.71,78.89) v3(84.83,76.73) v3(84.81,33.15) v3(84.91,81.28) v3(84.88,78.26) v3(84.91,77.42) v3(85.01,67.24) v3(85.04,54.89) v3(85.14,74.04) v3(85.16,69.51) v3(85.62,75.34) v3(85.75,64.75) v3(85.77,83.92) v3(85.85,69.24) v3(85.82,33.15) v3(86.05,74.35) v3(86.38,74.73) v3(86.56,62.51) v3(86.64,41.67) v3(86.69,63.81) v3(86.81,54.89) v3(86.84,33.15) v3(86.92,83.57) v3(87.12,74.83) v3(87.32,59.08) v3(87.4,33.55) v3(87.86,33.15) v3(88.03,75.59) v3(88.19,65.3) v3(88.19,64.42) v3(88.21,63.53) v3(88.24,60.76) v3(88.34,82.86) v3(88.44,67.26) v3(88.41,34.82) v3(88.54,33.81) v3(88.57,54.89) v3(88.82,83.72) v3(88.9,64.37) v3(88.87,33.15) v3(89.3,57.14) v3(89.38,34.95) v3(89.43,33.81) v3(89.56,64.31) v3(89.58,59.69) v3(89.94,62.66) v3(89.89,33.15) v3(90.01,40.16) v3(90.12,67.34) v3(90.09,42.98) v3(90.52,83.24) v3(90.52,41.23) v3(90.5,38.71) v3(90.57,33.81) v3(90.75,37.11) v3(90.9,33.15) v3(91,84) v3(91.11,64.14) v3(91.21,35.42) v3(91.26,62.43) v3(91.31,44.45) v3(91.26,38.79) v3(91.59,46.86) v3(91.72,33.81) v3(91.92,33.15) v3(92.05,69.37) v3(92.05,68.48) v3(92.05,66.7) v3(92.05,65.81) v3(92.05,64.92) v3(92,36.2) v3(92.1,83.62) v3(92.12,83.01) v3(92.07,71.15) v3(92.07,70.26) v3(92.06,67.59) v3(92.38,44.43) v3(92.48,46.86) v3(92.63,49.81) v3(92.73,33.81) v3(92.83,35.46) v3(92.94,33.15) v3(93.21,51.87) v3(93.52,73.46) v3(93.49,57.3) v3(93.65,62.23) v3(93.75,33.81) v3(93.93,84.86) v3(93.88,64.16) v3(93.95,62.92) v3(93.95,33.15) v3(94.05,82.68) v3(94.69,73.41) v3(94.76,33.81) v3(94.89,86.06) v3(94.97,33.15) v3(95.17,46.86) v3(95.43,75.1) v3(95.4,35.31) v3(95.53,60.57) v3(95.48,59.82) v3(95.58,75.57) v3(95.81,59.49) v3(95.91,33.81) v3(95.98,33.15) v3(96.21,59.56) v3(96.16,46.76) v3(96.64,35.33) v3(96.75,75.52) v3(96.69,59.95) v3(96.9,74.3) v3(96.89,37.67) v3(96.97,59.39) v3(97,33.15) v3(97.05,33.81) v3(97.43,49.9) v3(97.56,35.28) v3(98.02,33.15) v3(98.07,33.81) v3(98.19,60.59) v3(98.45,35.28) v3(98.6,38.84) v3(98.7,47.04) v3(98.99,73.51) v3(99.03,33.15) v3(99.21,33.81) v3(99.29,37.7) v3(99.34,35.28) v3(99.36,38.79) v3(99.59,47.04) v3(100.05,33.15) v3(100.23,44.77) v3(100.23,42.98) v3(100.23,33.81) v3(100.28,38.53) v3(100.35,37.19) v3(100.73,38.76) v3(100.81,59.92) v3(101,75.21) v3(101.09,52.25) v3(101.09,50.88) v3(101.06,33.15) v3(101.22,85.47) v3(101.22,54.94) v3(101.19,36.17) v3(101.34,42.65) v3(101.37,33.81) v3(101.5,81.31) v3(101.5,37.24) v3(101.65,51.61) v3(101.65,43.44) v3(101.83,84.3) v3(101.8,40.9) v3(101.9,60.12) v3(102,62.3) v3(102.08,50.7) v3(102.08,33.15) v3(102.23,43.46) v3(102.21,40.9) v3(102.38,36.86) v3(102.46,54.15) v3(102.51,33.81) v3(102.71,82.53) v3(102.69,55.88) v3(102.65,44.48) v3(102.66,40.9) v3(103.02,77.34) v3(103.1,33.15) v3(103.27,85.24) v3(103.55,45.06) v3(103.55,44.6) v3(103.55,44.15) v3(103.6,39.35) v3(103.63,34.85) v3(103.76,77.34) v3(103.78,33.81) v3(104.09,50.95) v3(104.39,83.57) v3(104.37,45.39) v3(104.52,44.2) v3(104.72,42.65) v3(104.8,78.16) v3(104.9,81.92) v3(104.95,39.35) v3(104.9,38.28) v3(104.92,37.24) v3(104.92,36.22) v3(104.92,35.08) v3(104.92,33.94) v3(105.23,52.05) v3(105.31,83.62) v3(105.31,46.13) v3(105.89,54.36) v3(106.09,55.81) v3(106.09,47.35) v3(106.19,34.14) v3(106.32,39.07) v3(106.55,85.45) v3(106.6,84.51) v3(106.8,81.69) v3(106.8,74.83) v3(106.98,55.93) v3(107.21,48.29) v3(107.34,46.61) v3(107.64,72.75) v3(107.74,68.35) v3(107.72,44.53) v3(107.67,42.17) v3(107.79,70.92) v3(107.77,47.37) v3(107.88,73.14) v3(108.02,69.57) v3(108.28,71.88) v3(108.29,70.72) v3(108.4,64.03) v3(108.48,66.07) v3(108.48,60.53) v3(108.51,58.5) v3(108.53,48.34) v3(108.61,53.77) v3(108.58,49.99) v3(109.14,46.25) v3(109.22,44.58) v3(109.34,85.45) v3(109.45,71.02) v3(109.42,66.55) v3(109.39,54.64) v3(109.45,50.4) v3(109.5,59.49) v3(109.5,43.28) v3(109.6,65.76) v3(109.73,72.02) v3(109.83,72.54) v3(110.03,60.38) v3(110.18,61.7) v3(110.16,55.58) v3(110.41,85.55) v3(110.41,62.18) v3(110.41,53.11) v3(110.51,68.81) v3(110.69,46.23) v3(110.77,68.28) v3(110.84,60.89) v3(110.84,59.92) v3(110.78,56.03) v3(111.12,41.89) v3(111.32,43.23) v3(111.4,68.81) v3(111.35,53.19) v3(111.5,68.25) v3(111.66,85.52) v3(111.71,67.62) v3(111.66,52.39) v3(111.78,73.31) v3(111.81,66.45) v3(111.81,65.3) v3(111.82,44.22) v3(112.61,72.34) v3(112.59,71.96) v3(112.6,71.54) v3(112.75,48.59) v3(112.72,38.74) v3(112.85,85.47) v3(112.8,74.91) v3(113.02,75.5) v3(113.15,68.84) v3(113.23,44.63) v3(113.18,41.84) v3(113.31,43.16) v3(113.86,45.77) v3(113.94,43.08) v3(114.07,68.81) v3(114.14,36.73) v3(114.12,34.65) v3(114.25,85.55) v3(114.27,66.57) v3(114.53,77.09) v3(114.55,50.88) v3(114.73,55.07) v3(114.68,38.79) v3(114.83,55.4) v3(114.91,79.12) v3(114.88,41.78) v3(114.96,68.81) v3(115.16,45.77) v3(115.44,78.26) v3(115.41,51.03) v3(115.47,85.55) v3(115.6,59.34) v3(115.59,54.97) v3(115.59,48.85) v3(115.59,46.2) v3(115.69,45.24) v3(115.85,68.81) v3(116.13,73.41) v3(116.1,66.63) v3(116.23,37.21) v3(116.33,42.14) v3(116.3,35.13) v3(116.48,54.97) v3(116.6,59.84) v3(116.81,85.6) v3(116.79,54.18) v3(117.12,51.89) v3(117.24,43.21) v3(117.55,73.53) v3(117.62,68.82) v3(117.6,57.84) v3(117.62,54.97) v3(117.8,38.71) v3(117.85,34.37) v3(117.98,85.55) v3(118.13,43.21) v3(118.11,36.37) v3(118.21,55.68) v3(118.21,54.87) v3(118.44,70.26) v3(118.39,46.76) v3(118.46,66.65) v3(118.64,72.75) v3(118.64,71.81) v3(118.74,65.69) v3(118.78,70.64) v3(118.89,46.76) v3(118.97,79.35) v3(119.02,43.21) v3(119.07,54.38) v3(119.2,85.52) v3(119.2,73.41) v3(119.33,69.6) v3(119.3,68.2) v3(119.44,71.86) v3(119.68,63.86) v3(119.78,78.54) v3(119.83,71.05) v3(120.14,72.11) v3(120.29,79.25) v3(120.34,76.58) v3(120.29,37.39) v3(120.32,34.8) v3(120.42,85.62) v3(120.37,75.41) v3(120.55,67.59) v3(120.72,65.38) v3(120.8,43.18) v3(120.93,66.57) v3(120.98,60.61) v3(120.95,59.92) v3(120.95,59.18) v3(121.13,81.66) v3(121.13,75.41) v3(121.26,84.76) v3(121.33,64.24) v3(121.41,59.31) v3(121.46,78.36) v3(121.61,76.46) v3(121.64,58.24) v3(121.82,68.1) v3(121.94,59.23) v3(122.07,69.62) v3(122.17,39.04) v3(122.25,37.49) v3(122.42,62.49) v3(122.48,34.85) v3(122.65,67.69) v3(123.03,40.79) v3(123.09,79.22) v3(123.34,78.51) v3(123.42,60.28) v3(123.39,54.76) v3(123.42,53.77) v3(123.44,52.86) v3(123.44,52) v3(123.44,51.03) v3(123.44,50.06) v3(123.44,49.23) v3(123.44,48.31) v3(123.44,47.45) v3(123.42,46.41) v3(123.42,45.21) v3(123.42,44.07) v3(123.42,43.05) v3(123.42,42.06) v3(123.42,41.28) v3(123.47,65.81) v3(123.49,64.03) v3(123.47,62.28) v3(123.47,59.44) v3(123.47,57.81) v3(123.47,56.67) v3(123.69,84.69) v3(124.1,68.23) v3(124.46,64.44) v3(124.48,62.33) v3(124.71,77.75) v3(124.71,76.38) v3(124.74,75.24) v3(124.69,56.47) v3(124.79,66.57) v3(124.86,65.97) v3(125.09,79.94) v3(125.09,57.33) v3(125.47,84.74) v3(125.65,79.58) v3(126.16,56.87) v3(126.31,79.1) v3(126.31,68.18) v3(126.41,78.23) v3(126.64,75.34) v3(126.56,73.56) v3(126.72,77.57) v3(126.67,71.58) v3(126.82,74.32) v3(127.05,79.07) v3(127,65.99) v3(127,63.3) v3(126.97,59.16) v3(127.1,73.56) v3(127.17,70.26) v3(127.71,79.38) v3(127.78,70.26) v3(128.06,78.36) v3(128.09,71.81) v3(128.22,73.84) v3(128.75,84.76) v3(128.72,55.3) v3(128.8,64.39) v3(128.8,63.45) v3(128.8,62.64) v3(128.8,61.95) v3(128.8,60.89) v3(128.8,59.54) v3(128.8,58.22) v3(128.8,56.82) v3(129.31,85.45) v3(129.31,70.33) v3(129.44,74.83) v3(129.41,71.81) v3(129.49,79.25) v3(130.04,77.37) v3(130.53,72.62) v3(130.73,70.28) v3(130.76,79.33) v3(130.91,74.17) v3(130.91,71.76) v3(131.21,67.26) v3(131.37,85.12) v3(131.47,70.11) v3(132.23,76.96) v3(132.18,67.36) v3(132.36,70.11) v3(132.76,78.31) v3(133.02,85.32) v3(132.97,79.35) v3(133.02,74.25) v3(133.25,70.08) v3(133.63,67.34) v3(133.65,75.34) v3(134.16,70.08) v3(134.54,84.53) v3(134.54,77.19) v3(134.9,74.32) v3(135,70.11) v3(135.63,83.85) v3(135.79,70.51) v3(135.91,82.78) v3(135.91,72.9) v3(135.91,72.37) v3(136.27,70.16) v3(136.42,85.17) v3(136.62,75.69) v3(136.8,70.08) v3(137,74.5) v3(137.36,82.04) v3(137.69,70.09) v3(137.82,80.88) v3(137.89,82.91) v3(138.02,67.57) v3(138.25,74.04) v3(138.2,71.65) v3(138.5,81.41) v3(138.58,83.95) v3(138.55,70.38) v3(139.04,67.57) v3(139.26,81.28) v3(139.47,85.04) v3(139.77,82.5) v3(140.05,67.57) v3(140.23,73.56) v3(140.28,81.1) v3(140.33,73.05) v3(140.33,72.67) v3(140.61,80.82) v3(140.87,70.61) v3(141.07,67.57) v3(141.21,72.96) v3(141.75,81.92) v3(141.93,82.35) v3(142.01,71.93) v3(142.08,67.57) v3(142.24,84.53) v3(142.29,86.29) v3(142.44,82.81) v3(142.39,73.74) v3(142.69,85.32) v3(143.07,70.59) v3(143.1,67.57) v3(143.25,86.29) v3(143.66,70.54) v3(143.83,72.14) v3(144.12,67.57) v3(144.19,86.29) v3(144.17,85.6) v3(144.19,70.69) v3(144.98,73.51) v3(145.13,67.57) v3(145.21,86.29) v3(145.92,85.37) v3(145.95,70.72) v3(146.15,67.57) v3(146.22,86.29) v3(147.24,86.29) v3(147.16,67.57) v3(147.37,71.15) v3(147.77,85.55) v3(147.85,73.55) v3(148.18,67.57) v3(148.26,86.29) v3(148.41,73.66) v3(148.41,72.32) v3(148.49,71.15) v3(148.74,78.89) v3(149.2,67.57) v3(149.27,86.29) v3(150.29,86.29) v3(150.57,85.55) v3(150.77,84.99) v3(150.9,78.13) v3(151.3,86.29) v3(151.28,76.73) v3(151.79,73.43) v3(151.91,81.56) v3(151.91,68.73) v3(151.99,67.34) v3(152.32,86.29) v3(152.7,68.81) v3(152.93,85.68) v3(153.21,68.61) v3(153.34,86.29) v3(153.36,69.75) v3(153.59,67.31) v3(153.82,68.84) v3(153.91,82.81) v3(153.91,81.79) v3(154.25,86.29) v3(154.38,68.61) v3(154.62,72.14) v3(154.75,79.88) v3(154.71,79) v3(154.71,78.11) v3(154.84,68.85) v3(155.04,67.26) v3(155.52,68.56) v3(156.18,84.94) v3(156.49,74.68) v3(156.61,69.34) v3(156.74,84.35) v3(157.02,67.95) v3(157.12,77.89) v3(157.96,69.93) v3(158.05,68.99) v3(158.14,67.41) v3(158.77,77.89) v3(159.1,84.18) v3(159.46,67.92) v3(159.75,77.6) v3(159.75,76.71) v3(160.18,79.25) v3(160.37,67.36) v3(160.5,84.71) v3(161.01,84.18) v3(161.49,84.71) v3(161.57,79) v3(161.62,68) v3(161.95,84.23) v3(162.25,84.71) v3(162.46,79) v3(162.48,67.36) v3(163.09,84.76) v3(163.37,84.18) v3(164.02,73.53) v3(164.16,84.76) v3(164.36,78.53) v3(164.87,84.1) v4(10.84,63.68) v4(14.17,55.22) v4(14.4,46.89) v4(15.21,56.41) v4(15.47,46.97) v4(16.81,53.72) v4(16.84,48.69) v4(16.81,47.14) v4(26.41,78.89) v4(26.46,80.04) v4(27.45,23.45) v4(27.84,75.19) v4(28.14,26.8) v4(28.67,76.79) v4(29.94,79.88) v4(30.81,54.76) v4(31.21,72.87) v4(35.76,12.12) v4(46.38,44.25) v4(47.93,43.66) v4(49.58,43.23) v4(51.33,43.23) v4(53.11,43.26) v4(54.89,43.26) v4(56.69,43.26) v4(62.91,68.86) v4(62.96,70.03) v4(65.31,67.24) v4(66.62,66.7) v4(66.96,67.43) v4(67.92,63.78) v4(67.99,67.39) v4(68.53,66.24) v4(68.83,62.66) v4(69.29,65) v4(70.17,65) v4(71.83,73.26) v4(72.39,73.23) v4(73.76,73.79) v4(75.18,73.23) v4(76.1,73.31) v4(77.47,73.18) v4(79.04,73.81) v4(103.83,57.81) v5(3.68,49.86) v5(4.34,49.84) v5(5.03,49.86) v5(5.71,49.84) v5(6.45,49.84) v5(7.21,49.84) v5(7.95,49.84) v5(8.71,49.84) v5(9.52,49.81) v5(10.28,49.79) v5(10.46,77.17) v5(10.61,78.94) v5(10.66,74.55) v5(10.92,42.95) v5(11.3,49.76) v5(11.45,42.95) v5(11.88,49.76) v5(12.14,60.33) v5(12.14,59.31) v5(12.14,58.29) v5(12.14,57.28) v5(12.14,56.26) v5(12.14,55.25) v5(12.14,54.23) v5(12.14,53.21) v5(12.14,52.2) v5(12.14,51.18) v5(12.14,50.17) v5(12.75,42.95) v5(13.56,42.95) v5(13.76,13.26) v5(13.76,12.42) v5(13.76,11.61) v5(13.79,10.9) v5(14.47,42.95) v5(14.63,10.9) v5(14.75,35.51) v5(15.03,10.06) v5(15.06,9.27) v5(15.16,42.04) v5(15.82,35.46) v5(16,41.96) v5(16.18,0.74) v5(16.81,35.46) v5(16.94,36.55) v5(16.94,0.74) v5(16.96,41.23) v5(17.01,39.68) v5(16.96,38.66) v5(16.96,37.62) v5(17.01,3.66) v5(17.01,2.62) v5(16.99,1.58) v5(21.99,42.06) v5(23.39,42.19) v5(23.64,41.56) v5(24.08,81.84) v5(25.3,34.06) v5(27.84,35.46) v5(28.6,39.65) v5(28.72,36.09) v5(29.93,42.32) v5(29.93,41.77) v5(30.12,38.13) v5(39.65,4.22) v5(39.62,2.69) v5(39.62,1.47) v5(39.62,0.71) v5(44.5,13.34) v5(45.72,23.8) v5(45.72,23.01) v5(45.69,21.95) v5(45.67,20.19) v5(45.67,19.36) v5(45.67,18.31) v5(46.55,33.15) v5(47.57,33.15) v5(48.21,75.03) v5(48.59,33.15) v5(49.6,33.15) v5(50.62,33.15) v5(51.63,33.15) v5(52.65,33.15) v5(53.67,33.15) v5(54.68,33.15) v5(55.7,33.15) v5(56.71,33.15) v5(57.73,33.15) v5(58.75,33.15) v5(59.76,33.15) v5(60.78,33.15) v5(61.79,33.15) v5(62.81,33.15) v5(63.83,33.15) v5(64.84,33.15) v5(65.86,33.15) v5(66.87,33.15) v5(67.89,33.15) v5(68.91,33.15) v5(69.92,33.15) v5(70.94,33.15) v5(71.95,33.15) v5(72.97,33.15) v5(73.63,33.15) v5(74.65,33.15) v5(75.16,53.62) v5(75.66,33.15) v5(76.53,58.19) v5(76.53,57.38) v5(76.63,55.68) v5(76.6,54.89) v5(76.68,33.15) v5(77.09,55.65) v5(77.06,54.87) v5(77.7,33.15) v5(78.71,33.15) v5(79.73,33.15) v5(80.74,61.24) v5(80.74,33.15) v5(80.77,63.12) v5(81.76,33.15) v5(82.19,66.47) v5(82.7,65.36) v5(82.78,33.15) v5(83.59,64.49) v5(83.79,33.15) v5(84.48,64.64) v5(84.81,33.15) v5(85.01,67.24) v5(85.82,33.15) v5(86.84,33.15) v5(87.86,33.15) v5(88.19,65.3) v5(88.19,64.42) v5(88.21,63.53) v5(88.44,67.26) v5(88.87,33.15) v5(89.56,64.31) v5(89.89,33.15) v5(90.12,67.34) v5(90.9,33.15) v5(91.92,33.15) v5(92.05,69.37) v5(92.05,68.48) v5(92.07,71.15) v5(92.07,70.26) v5(92.94,33.15) v5(93.52,73.46) v5(93.95,33.15) v5(94.69,73.41) v5(94.97,33.15) v5(95.58,75.57) v5(95.98,33.15) v5(96.75,75.52) v5(97,33.15) v5(98.02,33.15) v5(99.03,33.15) v5(100.05,33.15) v5(100.81,59.92) v5(101.06,33.15) v5(101.9,60.12) v5(102.08,33.15) v5(103.1,33.15) v5(117.07,70.54) v5(117.12,69.17) v5(117.12,68.2) v5(118.34,68.23) v5(118.39,69.37) v5(119,70.08) v5(119.22,67.36) v5(119.73,67.08) v5(120.04,68.78) v5(120.32,66.3) v5(121.13,65.66) v5(121.15,68.28) v5(121.71,65.28) v5(121.87,67.26) v5(122.15,66.4) v5(122.73,64.59) v5(122.98,68.33) v5(123.19,66.19) v5(123.52,64.64) v5(123.77,67.06) v5(124.25,65.36) v5(124.74,67.62) v5(125.14,68.66) v5(125.37,72.26) v5(125.45,71.1) v5(125.47,69.93) v5(125.68,82.78) v5(125.7,81.61) v5(126.16,82.2) v5(126.21,72.16) v5(127.12,73.03) v5(128.47,82.96) v5(128.47,81.43) v5(128.72,55.3) v5(128.8,64.39) v5(128.8,63.45) v5(128.8,62.64) v5(128.8,61.95) v5(128.8,60.89) v5(128.8,59.54) v5(128.8,58.22) v5(128.8,56.82) v5(129.56,82.02) v5(130.12,73.43) v5(130.63,82.98) v5(130.68,81.41) v5(131.26,73.61) v5(132.23,73.43) v5(132.38,81.59) v5(132.71,80.7) v5(133.55,73.41) v5(133.8,82.91) v5(133.85,81.48) v5(133.85,79.38) v5(135.23,79.88) v5(135.23,77.98) v5(135.33,81.46) v5(135.56,73.41) v5(136.04,77.6) v5(136.45,78.94) v5(136.67,73.74) v5(136.75,80.09) v5(137.46,76.53) v5(137.56,79.43) v5(137.59,78.03) v5(137.84,75.44) v5(138.02,67.57) v5(139.01,76.66) v5(139.04,74.96) v5(139.04,67.57) v5(139.06,77.9) v5(139.62,74.22) v5(140.05,67.57) v5(140.23,77.17) v5(140.87,75.46) v5(141.07,67.57) v5(141.5,76.23) v5(141.75,74.7) v5(142.08,67.57) v5(142.29,86.29) v5(143.1,67.57) v5(143.25,86.29) v5(144.12,67.57) v5(144.19,86.29) v5(145.13,67.57) v5(145.21,86.29) v5(146.15,67.57) v5(146.22,86.29) v5(147.24,86.29) v5(147.16,67.57) v5(148.18,67.57) v5(148.26,86.29) v5(149.2,67.57) v5(149.27,86.29) v5(150.29,86.29) v5(151.3,86.29) v5(152.32,86.29) v5(153.34,86.29) v5(154.25,86.29) v5(160.5,84.71) v5(161.49,84.71) v5(162.25,84.71) v5(163.09,84.76) v5(164.16,84.76) v6(49.11,57.09) v7(30.01,76.81) v7(30.01,76.31) v7(30.01,75.81) v7(30.01,75.31) v7(30.01,73.81) v7(30.01,71.81) v7(30.01,70.81) v7(30.01,57.66) v7(30.01,55.16) v7(30.01,54.66) v7(30.01,53.66) v7(30.01,53.16) v7(30.01,52.66) v7(30.51,77.31) v7(30.51,76.31) v7(30.51,75.81) v7(30.51,53.66) v7(30.51,53.16) v7(30.51,52.16) v7(31.01,77.31) v7(31.01,76.81) v7(31.01,75.81) v7(31.01,53.66) v7(31.01,52.66) v7(31.01,52.16) v7(31.51,77.31) v7(31.51,76.81) v7(31.51,76.31) v7(31.51,75.81) v7(31.51,71.81) v7(31.51,69.31) v7(31.51,60.16) v7(31.51,53.66) v7(31.51,53.16) v7(31.51,52.66) v7(31.51,52.16) v7(32.01,75.31) v7(32.01,74.81) v7(32.01,74.31) v7(32.01,73.81) v7(32.01,73.31) v7(32.01,72.81) v7(32.01,72.31) v7(32.01,71.81) v7(32.01,57.16) v7(32.01,56.66) v7(32.01,56.16) v7(32.01,55.66) v7(32.01,55.16) v7(32.01,54.66) v7(32.01,54.16) v7(32.01,52.16) v7(32.51,77.31) v7(32.51,75.31) v7(32.51,71.81) v7(32.51,69.31) v7(32.51,57.66) v7(32.51,54.16) v7(33.01,77.31) v7(33.01,75.31) v7(33.01,70.31) v7(33.01,69.81) v7(33.01,54.16) v7(33.51,75.31) v7(33.51,71.81) v7(33.51,70.31) v7(33.51,59.16) v7(33.51,54.16) v7(33.51,52.16) v7(34.01,75.31) v7(34.03,69.31) v7(34.01,54.16) v7(34.51,75.31) v7(34.51,54.16) v7(35.01,75.31) v7(35.01,71.81) v7(35.01,57.66) v7(35.01,54.16) v7(35.51,77.31) v7(35.51,75.81) v7(35.51,75.31) v7(35.51,74.81) v7(35.51,72.31) v7(35.51,69.31) v7(35.51,57.16) v7(35.51,55.66) v7(35.51,54.66) v7(35.51,52.16) v7(36.01,71.31) v7(36.01,69.31) v7(36.01,58.16) v7(36.51,77.31) v7(36.51,70.81) v7(36.51,58.66) v7(36.51,52.16) v7(37.01,69.81) v7(37.01,69.31) v7(37.01,60.16) v7(37.01,59.66) v7(37.01,55.16) v7(37.51,70.31) v7(37.51,69.31) v7(37.51,59.16) v7(43.28,68.48) v7(43.28,68.18) v7(43.38,71.17) v7(43.46,72.29) v7(43.66,72.06) v7(43.66,68.12) v7(43.66,64.16) v7(43.66,60.2) v7(43.66,57.37) v7(43.66,56.81) v7(43.95,63.88) v7(43.95,59.35) v7(44.02,70.67) v7(44.02,58.79) v7(44.09,72.98) v7(44.29,72.75) v7(44.3,68.12) v7(44.3,60.2) v7(44.3,56.16) v7(44.59,71.24) v7(44.59,68.97) v7(44.59,67.84) v7(44.59,66.71) v7(44.59,65.58) v7(44.59,63.88) v7(44.59,62.75) v7(44.59,61.62) v7(44.59,59.35) v7(44.59,58.22) v7(44.59,57.09) v7(44.87,56.16) v7(45.15,71.24) v7(45.15,69.54) v7(45.15,65.01) v7(45.15,64.45) v7(45.15,63.88) v7(45.15,63.31) v7(45.15,62.75) v7(45.15,61.05) v7(45.15,58.79) v7(45.15,57.09) v7(45.44,70.95) v7(45.44,68.69) v7(45.44,64.73) v7(45.44,64.16) v7(45.44,63.6) v7(45.44,62.46) v7(45.44,61.33) v7(45.44,60.77) v7(45.44,59.63) v7(45.44,57.94) v7(45.44,57.37) v7(45.49,55.58) v7(45.69,73.28) v7(45.72,68.97) v7(45.72,68.41) v7(45.72,64.45) v7(45.72,63.88) v7(45.72,62.75) v7(45.72,62.18) v7(45.72,61.05) v7(45.72,59.92) v7(45.72,59.35) v7(45.72,55.81) v7(45.92,73) v7(46,64.73) v7(46,63.6) v7(46,60.77) v7(46.28,71.24) v7(46.28,58.79) v7(46.28,57.09) v7(46.57,64.73) v7(46.57,63.6) v7(46.57,62.46) v7(46.57,61.33) v7(46.57,60.77) v7(46.57,59.63) v7(46.73,73.13) v7(46.73,72.8) v7(46.85,70.67) v7(46.85,58.79) v7(46.85,57.65) v7(47.14,55.73) v7(47.14,55.4) v7(47.42,71.24) v7(47.42,58.22) v7(47.42,57.09) v7(47.72,72.9) v7(47.72,72.57) v7(47.7,59.07) v7(47.7,57.94) v7(47.98,58.22) v7(48.55,71.24) v7(48.55,68.97) v7(48.55,59.35) v7(48.55,57.09) v7(48.79,71.56) v7(48.83,70.95) v7(48.83,59.07) v7(48.83,58.5) v7(48.83,57.94) v7(48.83,57.37) v7(48.79,56.77) v7(49.11,58.22) v7(49.11,57.65) v7(49.11,57.09) v7(49.4,69.26) v7(49.4,59.07) v7(49.4,57.94) v7(49.63,55.48) v7(49.68,71.24) v7(49.68,68.97) v7(49.68,57.09) v7(49.83,55.25) v7(49.96,69.26) v7(50.25,70.1) v7(50.25,58.22) v7(50.53,71.52) v7(50.53,70.39) v7(50.53,69.26) v7(50.53,59.07) v7(50.53,57.94) v7(50.81,71.24) v7(50.81,70.1) v7(50.81,58.22) v7(50.81,57.09) v7(50.81,56.45) v7(51.09,69.26) v7(51.38,71.8) v7(51.38,70.67) v7(51.38,68.97) v7(51.38,57.65) v7(51.66,70.39) v7(51.66,69.82) v7(51.66,57.94) v7(51.94,71.24) v7(51.94,70.1) v7(51.94,58.22) v7(51.94,57.09) v7(51.94,56.45) v7(52.23,70.39) v7(52.23,57.94) v7(53.07,71.24) v7(53.07,69.54) v7(53.07,57.09) v7(53.07,56.45) v7(53.36,59.07) v7(53.36,58.5) v7(53.36,57.94) v7(53.64,58.22) v7(53.92,69.26) v7(53.92,57.94) v7(54.21,71.88) v7(54.21,71.24) v7(54.21,58.79) v7(54.21,57.09) v7(54.21,56.45) v7(54.77,70.67) v7(54.77,70.1) v7(55.06,70.39) v7(55.06,69.26) v7(55.34,71.24) v7(55.34,70.1) v7(55.34,57.09) v7(55.34,56.45) v7(55.62,69.26) v7(55.62,59.07) v7(55.62,56.16) v7(56.19,70.39) v7(56.19,69.82) v7(56.19,69.26) v7(56.19,59.07) v7(56.19,58.5) v7(56.19,57.94) v7(56.47,71.24) v7(56.47,68.97) v7(56.47,68.41) v7(56.47,66.71) v7(56.47,66.14) v7(56.47,65.01) v7(56.47,63.88) v7(56.47,61.62) v7(56.47,61.05) v7(56.47,60.48) v7(56.47,59.92) v7(56.47,59.35) v7(56.47,57.09) v7(56.47,56.45) v7(56.75,69.26) v7(56.75,68.12) v7(56.75,67.56) v7(56.75,66.43) v7(56.75,65.29) v7(56.75,64.16) v7(56.75,63.03) v7(56.75,61.9) v7(56.75,60.2) v7(56.75,59.07) v7(57.04,70.67) v7(57.04,70.1) v7(57.04,69.54) v7(57.04,66.71) v7(57.04,58.22) v7(57.04,57.65) v7(57.32,68.12) v7(57.32,63.03) v7(57.32,61.9) v7(57.6,71.24) v7(57.6,70.67) v7(57.6,68.41) v7(57.6,66.71) v7(57.6,65.58) v7(57.6,64.45) v7(57.6,62.18) v7(57.6,61.62) v7(57.6,59.35) v7(57.6,58.22) v7(57.6,57.09) v7(57.6,56.45) v7(57.89,69.26) v7(57.89,68.69) v7(57.89,68.12) v7(57.89,67.56) v7(57.89,66.43) v7(57.89,65.86) v7(57.89,65.29) v7(57.89,64.73) v7(57.89,62.46) v7(57.89,61.9) v7(57.89,61.33) v7(57.89,60.2) v7(57.89,59.63) v7(57.89,59.07) v7(57.89,58.5) v7(58.17,70.67) v7(58.17,69.54) v7(58.17,68.97) v7(58.17,68.41) v7(58.17,67.27) v7(58.17,66.14) v7(58.17,65.58) v7(58.17,65.01) v7(58.17,64.45) v7(58.17,63.88) v7(58.17,62.75) v7(58.17,61.62) v7(58.17,61.05) v7(58.17,60.48) v7(58.17,59.92) v7(58.17,59.35) v7(58.17,58.79) v7(58.17,58.22) v7(58.17,57.65) v7(58.17,56.52) v7(58.45,70.39) v7(58.45,69.26) v7(58.45,68.12) v7(58.45,64.16) v7(58.45,63.03) v7(58.45,61.9) v7(58.45,60.77) v7(58.45,59.63) v7(58.45,58.5) v7(58.45,57.37) v7(58.45,56.16) v7(59.02,56.81) v7(59.02,56.16) v7(59.3,67.27) v7(59.3,56.52) v7(59.38,57.09) v7(59.66,56.81) v7(82.08,65.55) v7(82.08,65.15) v7(82.08,60.75) v7(82.48,65.55) v7(82.48,65.15) v7(82.48,60.75) v7(84.08,65.55) v7(84.48,61.15) v7(85.28,62.75) v7(85.68,62.75) v7(86.08,62.75) v7(86.88,65.15) v8(30.01,76.81) v8(30.01,76.31) v8(30.01,75.81) v8(30.01,75.31) v8(30.01,73.81) v8(30.01,71.81) v8(30.01,70.81) v8(30.01,57.66) v8(30.01,55.16) v8(30.01,54.66) v8(30.01,53.66) v8(30.01,53.16) v8(30.01,52.66) v8(30.51,77.31) v8(30.51,76.31) v8(30.51,75.81) v8(30.51,53.66) v8(30.51,53.16) v8(30.51,52.16) v8(31.01,77.31) v8(31.01,76.81) v8(31.01,75.81) v8(31.01,53.66) v8(31.01,52.66) v8(31.01,52.16) v8(31.51,77.31) v8(31.51,76.81) v8(31.51,76.31) v8(31.51,75.81) v8(31.51,71.81) v8(31.51,69.31) v8(31.51,60.16) v8(31.51,53.66) v8(31.51,53.16) v8(31.51,52.66) v8(31.51,52.16) v8(32.01,75.31) v8(32.01,74.81) v8(32.01,74.31) v8(32.01,73.81) v8(32.01,73.31) v8(32.01,72.81) v8(32.01,72.31) v8(32.01,71.81) v8(32.01,57.16) v8(32.01,56.66) v8(32.01,56.16) v8(32.01,55.66) v8(32.01,55.16) v8(32.01,54.66) v8(32.01,54.16) v8(32.01,52.16) v8(32.51,77.31) v8(32.51,75.31) v8(32.51,71.81) v8(32.51,69.31) v8(32.51,57.66) v8(32.51,54.16) v8(33.01,77.31) v8(33.01,75.31) v8(33.01,70.31) v8(33.01,69.81) v8(33.01,54.16) v8(33.51,75.31) v8(33.51,71.81) v8(33.51,70.31) v8(33.51,59.16) v8(33.51,54.16) v8(33.51,52.16) v8(34.01,75.31) v8(34.03,69.31) v8(34.01,54.16) v8(34.51,75.31) v8(34.51,54.16) v8(35.01,75.31) v8(35.01,71.81) v8(35.01,57.66) v8(35.01,54.16) v8(35.51,77.31) v8(35.51,75.81) v8(35.51,75.31) v8(35.51,74.81) v8(35.51,72.31) v8(35.51,69.31) v8(35.51,57.16) v8(35.51,55.66) v8(35.51,54.66) v8(35.51,52.16) v8(36.01,71.31) v8(36.01,69.31) v8(36.01,58.16) v8(36.51,77.31) v8(36.51,70.81) v8(36.51,58.66) v8(36.51,52.16) v8(37.01,69.81) v8(37.01,69.31) v8(37.01,60.16) v8(37.01,59.66) v8(37.01,55.16) v8(37.51,70.31) v8(37.51,69.31) v8(37.51,59.16) v8(43.28,68.48) v8(43.28,68.18) v8(43.38,71.17) v8(43.46,72.29) v8(43.66,72.06) v8(43.66,68.12) v8(43.66,64.16) v8(43.66,60.2) v8(43.66,57.37) v8(43.66,56.81) v8(43.95,63.88) v8(43.95,59.35) v8(44.02,70.67) v8(44.02,58.79) v8(44.09,72.98) v8(44.29,72.75) v8(44.3,68.12) v8(44.3,60.2) v8(44.3,56.16) v8(44.59,71.24) v8(44.59,70.1) v8(44.59,68.97) v8(44.59,67.84) v8(44.59,66.71) v8(44.59,65.58) v8(44.59,63.88) v8(44.59,62.75) v8(44.59,61.62) v8(44.59,60.48) v8(44.59,59.35) v8(44.59,58.22) v8(44.59,57.09) v8(44.87,56.16) v8(45.15,71.24) v8(45.15,69.54) v8(45.15,65.01) v8(45.15,64.45) v8(45.15,63.88) v8(45.15,63.31) v8(45.15,62.75) v8(45.15,61.05) v8(45.15,58.79) v8(45.15,57.09) v8(45.44,70.95) v8(45.44,70.39) v8(45.44,68.69) v8(45.44,64.73) v8(45.44,64.16) v8(45.44,63.6) v8(45.44,62.46) v8(45.44,61.33) v8(45.44,60.77) v8(45.44,59.63) v8(45.44,57.94) v8(45.44,57.37) v8(45.49,55.58) v8(45.69,73.28) v8(45.72,68.97) v8(45.72,68.41) v8(45.72,64.45) v8(45.72,63.88) v8(45.72,62.75) v8(45.72,62.18) v8(45.72,61.05) v8(45.72,59.92) v8(45.72,59.35) v8(45.72,55.81) v8(45.92,73) v8(46,64.73) v8(46,63.6) v8(46,60.77) v8(46.28,71.24) v8(46.28,69.54) v8(46.28,58.79) v8(46.28,57.09) v8(46.57,64.73) v8(46.57,63.6) v8(46.57,62.46) v8(46.57,61.33) v8(46.57,60.77) v8(46.57,59.63) v8(46.73,73.13) v8(46.73,72.8) v8(46.85,70.67) v8(46.85,69.54) v8(46.85,58.79) v8(46.85,57.65) v8(47.14,55.73) v8(47.14,55.4) v8(47.42,71.24) v8(47.42,70.1) v8(47.42,58.22) v8(47.42,57.09) v8(47.72,72.9) v8(47.72,72.57) v8(47.7,70.39) v8(47.7,69.26) v8(47.7,59.07) v8(47.7,57.94) v8(47.98,70.1) v8(47.98,58.22) v8(48.55,71.24) v8(48.55,68.97) v8(48.55,59.35) v8(48.55,57.09) v8(48.79,71.56) v8(48.83,70.95) v8(48.83,59.07) v8(48.83,58.5) v8(48.83,57.94) v8(48.83,57.37) v8(48.79,56.77) v8(49.11,59.35) v8(49.11,58.22) v8(49.11,57.65) v8(49.4,69.26) v8(49.4,59.07) v8(49.4,57.94) v8(49.63,55.48) v8(49.68,71.24) v8(49.68,68.97) v8(49.68,59.35) v8(49.68,57.09) v8(49.83,55.25) v8(49.96,69.26) v8(50.25,70.1) v8(50.25,58.22) v8(50.53,71.52) v8(50.53,70.39) v8(50.53,69.26) v8(50.53,59.07) v8(50.53,57.94) v8(50.81,71.24) v8(50.81,70.1) v8(50.81,58.22) v8(50.81,57.09) v8(50.81,56.45) v8(51.09,69.26) v8(51.38,71.8) v8(51.38,70.67) v8(51.38,68.97) v8(51.38,59.35) v8(51.38,57.65) v8(51.66,70.39) v8(51.66,69.82) v8(51.66,57.94) v8(51.94,71.24) v8(51.94,70.1) v8(51.94,58.22) v8(51.94,57.09) v8(51.94,56.45) v8(52.23,70.39) v8(52.23,57.94) v8(53.07,71.24) v8(53.07,69.54) v8(53.07,68.97) v8(53.07,57.09) v8(53.07,56.45) v8(53.36,70.39) v8(53.36,69.26) v8(53.36,59.07) v8(53.36,58.5) v8(53.36,57.94) v8(53.64,70.1) v8(53.64,58.22) v8(53.92,70.39) v8(53.92,69.26) v8(53.92,57.94) v8(54.21,71.88) v8(54.21,71.24) v8(54.21,59.35) v8(54.21,58.79) v8(54.21,57.09) v8(54.21,56.45) v8(54.49,69.26) v8(54.77,70.67) v8(54.77,70.1) v8(54.77,68.97) v8(55.06,70.39) v8(55.06,69.26) v8(55.06,59.07) v8(55.34,71.24) v8(55.34,70.1) v8(55.34,68.97) v8(55.34,57.09) v8(55.34,56.45) v8(55.62,69.26) v8(55.62,59.07) v8(55.62,56.16) v8(56.19,70.39) v8(56.19,69.82) v8(56.19,69.26) v8(56.19,59.07) v8(56.19,58.5) v8(56.19,57.94) v8(56.47,71.24) v8(56.47,68.97) v8(56.47,68.41) v8(56.47,66.71) v8(56.47,66.14) v8(56.47,65.01) v8(56.47,63.88) v8(56.47,62.75) v8(56.47,62.18) v8(56.47,61.62) v8(56.47,61.05) v8(56.47,60.48) v8(56.47,59.92) v8(56.47,59.35) v8(56.47,57.09) v8(56.47,56.45) v8(56.75,69.26) v8(56.75,68.12) v8(56.75,67.56) v8(56.75,66.43) v8(56.75,65.29) v8(56.75,64.16) v8(56.75,63.03) v8(56.75,61.9) v8(56.75,60.2) v8(56.75,59.07) v8(57.04,70.67) v8(57.04,70.1) v8(57.04,69.54) v8(57.04,66.71) v8(57.04,62.75) v8(57.04,61.05) v8(57.04,58.22) v8(57.04,57.65) v8(57.32,68.12) v8(57.32,63.03) v8(57.32,62.46) v8(57.32,61.9) v8(57.32,60.77) v8(57.6,71.24) v8(57.6,70.67) v8(57.6,68.41) v8(57.6,66.71) v8(57.6,65.58) v8(57.6,64.45) v8(57.6,62.18) v8(57.6,61.62) v8(57.6,60.48) v8(57.6,59.35) v8(57.6,58.22) v8(57.6,57.09) v8(57.6,56.45) v8(57.89,69.26) v8(57.89,68.69) v8(57.89,68.12) v8(57.89,67.56) v8(57.89,66.43) v8(57.89,65.86) v8(57.89,65.29) v8(57.89,64.73) v8(57.89,62.46) v8(57.89,61.9) v8(57.89,61.33) v8(57.89,60.77) v8(57.89,60.2) v8(57.89,59.63) v8(57.89,59.07) v8(57.89,58.5) v8(57.89,56.16) v8(58.17,70.67) v8(58.17,69.54) v8(58.17,68.97) v8(58.17,68.41) v8(58.17,67.27) v8(58.17,66.71) v8(58.17,66.14) v8(58.17,65.58) v8(58.17,65.01) v8(58.17,64.45) v8(58.17,63.88) v8(58.17,62.75) v8(58.17,61.62) v8(58.17,61.05) v8(58.17,60.48) v8(58.17,59.92) v8(58.17,59.35) v8(58.17,58.79) v8(58.17,58.22) v8(58.17,57.65) v8(58.17,56.52) v8(58.45,70.39) v8(58.45,69.26) v8(58.45,68.12) v8(58.45,64.16) v8(58.45,63.03) v8(58.45,61.9) v8(58.45,60.77) v8(58.45,59.63) v8(58.45,58.5) v8(58.45,57.37) v8(58.45,56.16) v8(59.02,56.81) v8(59.02,56.16) v8(59.3,67.27) v8(59.3,56.52) v8(59.38,66.71) v8(59.38,57.09) v8(59.66,56.81) v8(82.08,65.55) v8(82.08,65.15) v8(82.08,60.75) v8(82.48,65.55) v8(82.48,65.15) v8(82.48,60.75) v8(84.08,65.55) v8(84.48,61.15) v8(85.28,62.75) v8(85.68,62.75) v8(86.08,62.75) v8(86.88,65.15) v9(1.55,73.31) v9(1.55,71.91) v9(1.5,49.35) v9(1.5,47.58) v9(1.5,46.41) v9(1.5,43.38) v9(1.67,74.63) v9(1.98,70.59) v9(1.98,69.39) v9(1.98,67.79) v9(1.98,64.06) v9(1.98,62.82) v9(2.1,76.53) v9(2.69,78.03) v9(2.92,49.73) v9(3.1,40.54) v9(3.76,41.48) v9(4.59,76.73) v9(5.51,61.27) v9(6.78,61.27) v9(7.95,83.77) v9(8.05,61.27) v9(9.29,84.41) v9(9.32,61.27) v9(9.67,86.06) v9(10.59,61.27) v9(11.3,86.13) v9(11.86,61.27) v9(12.6,86.16) v9(13.92,86.16) v9(13.87,35.43) v9(13.87,34.16) v9(13.87,32.89) v9(13.87,31.62) v9(13.87,30.35) v9(13.87,29.08) v9(13.87,27.81) v9(13.87,26.54) v9(13.87,25.27) v9(13.87,24) v9(13.87,22.73) v9(13.87,21.46) v9(13.87,20.19) v9(13.87,18.92) v9(13.87,17.65) v9(13.87,16.38) v9(13.87,15.11) v9(13.87,13.84) v9(16.2,5.01) v9(16.28,3.66) v9(16.53,86.16) v9(18.56,16.66) v9(18.56,15.98) v9(18.89,86.13) v9(19.63,15.19) v9(19.76,84.38) v9(20.29,15.19) v9(20.9,84.38) v9(22.04,84.38) v9(23.34,84.38) v9(26.06,84.38) v9(26.82,7.01) v9(27.15,84.38) v9(28.24,84.38) v9(30.43,84.38) v9(31.7,84.38) v9(32.03,16.16) v9(32.97,84.38) v9(33.8,16.28) v9(34.24,84.38) v9(34.82,15.9) v9(35.51,84.38) v9(36.09,19.31) v9(36.7,20.52) v9(36.78,84.38) v9(37.11,23.6) v9(37.11,21.62) v9(38.05,84.38) v9(39.23,14.91) v9(39.32,84.38) v9(39.85,16.61) v9(40,15.87) v9(40.01,15.05) v9(40.1,22.35) v9(40.07,21.29) v9(40.09,20.2) v9(40.08,19.4) v9(40.06,18.72) v9(40.1,17.78) v9(40.1,17.16) v9(40.59,84.38) v9(40.92,11.63) v9(40.92,11.03) v9(40.89,0.79) v9(41.86,84.38) v9(41.91,0.79) v9(42.64,21.92) v9(42.64,21.3) v9(42.64,16.98) v9(42.64,15.61) v9(42.74,26.73) v9(42.67,19.96) v9(42.65,16.35) v9(42.68,14.79) v9(42.69,13.49) v9(42.75,25.58) v9(42.75,20.68) v9(42.95,0.79) v9(43.13,84.38) v9(43.17,26.21) v9(43.2,17.25) v9(43.32,15.65) v9(43.35,14.94) v9(43.37,25.6) v9(43.41,16.46) v9(43.57,26.72) v9(43.63,12.75) v9(43.63,11.48) v9(43.63,10.21) v9(43.63,8.94) v9(43.63,7.67) v9(43.63,6.4) v9(43.63,5.13) v9(43.63,3.86) v9(43.63,2.59) v9(43.63,1.32) v9(43.66,14.28) v9(43.94,26.21) v9(43.99,25.61) v9(43.96,15.29) v9(44.26,26.72) v9(44.4,84.38) v9(44.42,16.21) v9(44.58,26.21) v9(44.61,25.59) v9(44.62,17.02) v9(44.84,15.75) v9(44.83,14.68) v9(44.94,26.69) v9(44.98,13.9) v9(45.26,26.12) v9(45.39,17.38) v9(45.55,25.55) v9(45.61,26.7) v9(45.62,24.66) v9(45.63,20.85) v9(45.62,16.54) v9(45.62,15.27) v9(45.67,84.38) v9(48.21,84.38) v9(49.48,84.38) v9(52.02,84.38) v9(53.87,85.07) v9(55.06,85.09) v9(56.36,85.09) v9(64.06,84.84) v9(67.03,85.65) v9(68.14,85.65) v9(79.17,86.16) v9(80.44,86.16) v9(81.71,86.16) v9(82.98,86.16) v9(84.25,86.16) v9(84.4,85.37) v9(84.93,84.66) v9(86.2,84.66) v9(87.47,84.66) v9(88.74,84.66) v9(90.01,84.66) v9(91.34,84.66) v9(92.61,84.66) v9(92.76,86.13) v9(94.18,86.16) v9(100.91,86.16) v9(102.18,86.16) v9(103.45,86.16) v9(104.72,86.16) v9(105.99,86.16) v9(106.75,33.28) v9(108.53,86.16) v9(112.59,33.28) v9(113.86,33.28) v9(115.13,33.28) v9(116.4,33.28) v9(117.67,33.28) v9(118.94,33.28) v9(120.21,33.28) v9(121.48,33.28) v9(122.75,33.28) v9(123.21,33.78) v9(123.31,38.94) v9(123.31,37.67) v9(123.31,36.4) v9(123.31,35.13) v9(125.14,55.37) v9(126.51,55.37) v9(127.78,55.37) v9(128.29,86.16) v9(129.56,86.16) v9(130.27,66.68) v9(130.83,86.16) v9(131.54,66.68) v9(132.1,86.16) v9(132.81,66.68) v9(133.37,86.16) v9(134.08,66.68) v9(134.64,86.16) v9(135.91,86.16) v9(137.18,86.16) v9(138.45,86.16) v9(139.72,86.16) v9(140.15,70.72) v9(140.79,86.16) v9(141.65,86.16) v9(143.3,72.19) v9(155.37,86.16) v9(156.08,85.93) v9(156.74,86.16) v9(162.33,66.68) v9(165.1,86.16) v9(165.71,85.47) v9(165.91,86.11) v9(166.14,66.68) v9(167.41,73.31) v9(167.41,66.68) v9(168.68,66.68) v9(172.59,73.79) v9(175.03,73.59) v10(3.71,49.86) v10(4.8,49.86) v10(5.86,49.86) v10(7.11,49.86) v10(8.45,49.86) v10(9.5,49.86) v10(10.46,49.86) v10(11.2,49.86) v10(12.14,60.12) v10(12.14,59.11) v10(12.14,58.09) v10(12.14,57.08) v10(12.14,56.06) v10(12.14,55.04) v10(12.14,54.03) v10(12.14,53.01) v10(12.14,52) v10(12.14,50.98) v10(12.14,49.96) v10(14.55,63.65) v10(16.58,63.83) v10(27.2,44.1) v10(28.06,40.57) v10(28.14,37.8) v10(28.85,42.47) v10(29.51,37.34) v10(29.74,44.1) v10(30.4,42.27) v10(30.73,39.09) v10(31.29,42.09) v10(31.85,37.21) v10(31.9,40.49) v10(33.3,44.1) v10(34.31,44.1) v10(35.05,10.82) v10(35.46,44.1) v10(36.78,10.8) v10(37.11,42.14) v10(37.49,44.1) v10(38.5,44.1) v10(39.65,42.14) v10(39.7,38.41) v10(41.04,39.75) v10(41.37,36.58) v10(43.46,37.42) v10(50.7,63.69) v10(50.97,61.3) v10(51.8,66.54) v10(52.07,66.07) v10(60.93,74.2) v10(103.81,56.47) v10(128.44,55.27) v10(128.8,66.02) v10(128.8,65) v10(128.8,63.98) v10(128.8,62.97) v10(128.8,61.95) v10(128.8,60.94) v10(128.8,59.92) v10(128.8,58.9) v10(128.8,57.89) v10(128.8,56.87) v10(128.8,55.86) v10(137.99,67.57) v10(139.01,67.57) v10(140.03,67.57) v10(141.04,67.57) v10(142.06,67.57) v10(143.07,67.57) v10(144.09,67.57) v10(145.11,67.57) v10(146.12,67.57) v10(146.96,85.62) v10(147.14,67.57) v10(147.34,85.65) v10(148.15,67.57) v10(148.49,85.62) v10(149.17,67.57) v10(149.37,85.6) v11(1.93,68.86) v11(1.85,61.98) v11(1.98,72.65) v11(2.13,44.06) v11(2.46,43.03) v11(2.94,63.04) v11(2.99,68.12) v11(2.99,43.8) v11(3.15,73.51) v11(3.15,71.73) v11(3.1,66.85) v11(3.2,69.37) v11(3.2,64.59) v11(3.35,48.8) v11(3.37,76.02) v11(3.71,49.86) v11(3.78,61.42) v11(4.05,49.08) v11(4.21,43) v11(4.8,49.86) v11(4.92,45.37) v11(5.25,49.08) v11(5.66,63.1) v11(5.89,75.19) v11(5.86,49.86) v11(5.85,49.08) v11(6.17,48.13) v11(6.58,69.22) v11(6.73,67.59) v11(6.85,65.56) v11(7.11,49.86) v11(7.21,77.29) v11(7.41,62.33) v11(7.46,72.44) v11(7.46,43.31) v11(7.64,70.46) v11(7.69,74.25) v11(7.69,73.33) v11(7.95,46.03) v11(8.4,69.22) v11(8.45,49.86) v11(8.68,62.79) v11(8.89,72.04) v11(8.91,66.22) v11(9.04,76.81) v11(9.06,78.18) v11(9.14,65.48) v11(9.22,83.01) v11(9.27,79.33) v11(9.32,70.51) v11(9.55,63.04) v11(9.5,49.86) v11(9.6,75.44) v11(9.78,81.94) v11(9.75,46.03) v11(10,80.42) v11(9.98,73.59) v11(10,71.1) v11(10.11,65.99) v11(10.18,67.84) v11(10.31,43.08) v11(10.46,49.86) v11(10.56,68.86) v11(10.74,67.62) v11(10.75,48.8) v11(10.94,79.27) v11(10.94,75.24) v11(10.87,66.52) v11(10.97,72.65) v11(11.1,73.26) v11(11.2,49.86) v11(11.43,62.51) v11(11.68,74.8) v11(11.71,64.15) v11(11.71,63.15) v11(11.76,80.14) v11(12.14,60.12) v11(12.14,59.11) v11(12.14,58.09) v11(12.14,57.08) v11(12.14,56.06) v11(12.14,55.04) v11(12.14,54.03) v11(12.14,53.01) v11(12.14,52) v11(12.14,50.98) v11(12.14,49.96) v11(12.32,81.13) v11(12.57,82.09) v11(12.63,43.46) v11(13.03,62.61) v11(13.1,57.43) v11(13.41,59.29) v11(13.41,55.45) v11(13.69,81.23) v11(13.65,65.06) v11(13.71,50.52) v11(13.84,83.62) v11(13.84,61.11) v11(13.87,49.23) v11(14,57.56) v11(14.12,63.1) v11(14.4,44.35) v11(14.47,42.95) v11(14.55,63.65) v11(14.65,62.46) v11(14.88,82.36) v11(15,57.56) v11(15.21,59.08) v11(15.21,49.2) v11(15.26,51.68) v11(15.29,41.99) v11(15.41,54.38) v11(15.43,15.27) v11(15.43,14.38) v11(15.54,29.82) v11(15.55,65.34) v11(15.63,44.99) v11(15.64,22.99) v11(15.77,83.26) v11(15.9,61.62) v11(16.02,82.46) v11(16.13,27.1) v11(16.29,57.56) v11(16.25,18.54) v11(16.45,62.46) v11(16.58,63.83) v11(16.56,49.51) v11(16.81,59.29) v11(16.94,60.2) v11(16.93,42.95) v11(17.07,41.05) v11(17.21,16.16) v11(17.21,15.27) v11(17.21,14.38) v11(17.29,57.56) v11(17.4,58.85) v11(17.42,43.28) v11(17.4,37.62) v11(17.42,11.93) v11(17.6,61.52) v11(17.6,8.05) v11(17.7,26.54) v11(17.7,18.78) v11(17.75,20.73) v11(17.93,40.74) v11(17.93,32.28) v11(18.21,23.17) v11(18.28,57.53) v11(18.28,53.98) v11(18.36,84.18) v11(18.4,82.58) v11(18.44,59.68) v11(18.55,65.34) v11(18.69,49.89) v11(18.77,46.56) v11(18.95,47.63) v11(18.89,38.71) v11(18.92,11.36) v11(19,28.58) v11(19.15,65.34) v11(19.38,56.06) v11(19.73,18.26) v11(19.81,51.59) v11(19.86,54.56) v11(20.04,82.32) v11(20.09,46.76) v11(20.22,61.57) v11(20.28,41.92) v11(20.35,65.34) v11(20.39,60.4) v11(20.43,45.75) v11(20.47,11.84) v11(20.6,19.29) v11(20.6,10.95) v11(20.6,10.06) v11(20.76,36.86) v11(20.76,35.97) v11(20.76,35.08) v11(20.76,34.19) v11(20.76,33.3) v11(20.93,59.46) v11(20.89,58.32) v11(20.89,57.43) v11(21.02,81.43) v11(21.05,65.06) v11(21.49,53.62) v11(21.49,41.9) v11(21.52,12.6) v11(21.61,83.47) v11(21.71,35.84) v11(21.87,61.75) v11(22.04,45.39) v11(22.02,31.01) v11(22.16,52.86) v11(22.2,48.64) v11(22.25,46.23) v11(22.27,65.28) v11(22.27,38.94) v11(22.5,18.91) v11(22.58,53.98) v11(22.68,54.74) v11(23.01,40.67) v11(23.14,42.52) v11(23.26,83.54) v11(23.34,31.45) v11(23.52,44.15) v11(23.64,66.7) v11(23.64,65.43) v11(23.64,32.69) v11(23.77,82.58) v11(23.77,81.81) v11(23.77,71.53) v11(23.77,70.26) v11(23.77,69.11) v11(23.77,67.97) v11(23.9,80.16) v11(23.9,79.15) v11(23.9,77.88) v11(23.9,76.61) v11(23.9,75.34) v11(23.9,74.07) v11(23.9,72.8) v11(24.1,35.49) v11(24.38,37.62) v11(24.36,29.54) v11(24.41,29.14) v11(24.61,80.6) v11(24.63,79.35) v11(24.63,75.19) v11(24.63,70.21) v11(24.61,68.07) v11(24.61,64.95) v11(24.66,76.48) v11(24.66,72.85) v11(24.74,39.9) v11(24.79,47.02) v11(24.79,14.89) v11(24.79,10.82) v11(25.04,82.58) v11(24.99,24.18) v11(25.04,14.38) v11(25.09,42.85) v11(25.09,28.47) v11(25.07,19.53) v11(25.17,77.46) v11(25.17,74.66) v11(25.17,72.84) v11(25.17,70.93) v11(25.24,34.19) v11(25.3,57.98) v11(25.3,56.2) v11(25.3,53.53) v11(25.3,50.88) v11(25.42,25.63) v11(25.5,32.46) v11(25.78,17.1) v11(26.06,80.25) v11(26.06,75.72) v11(26.14,74.83) v11(26.06,72.96) v11(26.14,69.37) v11(26.14,68.48) v11(26.14,67.59) v11(26.06,47.02) v11(26.18,56.38) v11(26.21,53.62) v11(26.18,49.09) v11(26.31,82.58) v11(26.27,61.75) v11(26.27,60.86) v11(26.27,59.97) v11(26.27,54.51) v11(26.57,43.46) v11(26.57,42.44) v11(26.57,41.43) v11(26.57,40.54) v11(26.57,39.52) v11(26.57,38.51) v11(26.57,37.36) v11(26.57,36.35) v11(26.57,35.33) v11(26.57,34.19) v11(26.57,32.92) v11(26.57,31.78) v11(26.57,30.63) v11(26.57,29.62) v11(26.57,25.81) v11(26.57,24.79) v11(26.57,23.65) v11(26.57,22.63) v11(26.57,21.49) v11(26.69,28.47) v11(26.95,72.96) v11(26.95,71.19) v11(27.07,58.15) v11(27.07,56.38) v11(27.2,44.1) v11(27.33,47.02) v11(27.45,82.58) v11(27.71,28.35) v11(27.81,30.01) v11(27.94,36.43) v11(28.05,21.36) v11(28.05,20.47) v11(28.05,19.58) v11(28.05,18.7) v11(28.06,40.57) v11(28.06,39.04) v11(28.14,37.8) v11(28.06,29.71) v11(28.34,44.1) v11(28.34,13.62) v11(28.39,41.53) v11(28.6,47.02) v11(28.72,82.58) v11(28.68,29.74) v11(28.72,26.19) v11(28.85,42.47) v11(28.85,28.35) v11(29.36,10.95) v11(29.51,37.34) v11(29.61,80.25) v11(29.74,49.09) v11(29.74,44.1) v11(29.74,23.14) v11(29.74,13.62) v11(29.87,47.02) v11(29.87,26.19) v11(29.87,15.23) v11(29.99,82.58) v11(29.99,65.43) v11(29.99,64.01) v11(29.99,24.66) v11(30.12,10.82) v11(30.4,42.27) v11(30.38,28.35) v11(30.63,18.29) v11(30.63,17.83) v11(30.63,17.27) v11(30.73,39.09) v11(30.68,22.71) v11(30.68,19.23) v11(30.65,18.77) v11(30.76,19.74) v11(30.76,15.23) v11(30.88,24.66) v11(30.91,16.87) v11(30.88,10.95) v11(31.01,44.1) v11(31.01,26.19) v11(31.01,18.37) v11(31.01,17.86) v11(31.04,17.3) v11(31.14,47.02) v11(31.11,19.28) v11(31.11,18.85) v11(31.14,13.62) v11(31.21,83.82) v11(31.26,82.58) v11(31.29,42.09) v11(31.42,29.73) v11(31.44,17.27) v11(31.39,16.87) v11(31.39,15.01) v11(31.52,28.35) v11(31.65,65.4) v11(31.65,64.07) v11(31.85,37.21) v11(31.77,24.66) v11(31.79,21.84) v11(31.79,20.64) v11(31.82,16.87) v11(31.9,40.49) v11(31.95,29.66) v11(31.9,17.27) v11(31.9,14.89) v11(32.15,44.1) v11(32.15,26.19) v11(32.18,16.89) v11(32.33,36.23) v11(32.33,35.23) v11(32.31,17.27) v11(32.28,14.76) v11(32.36,83.82) v11(32.41,47.02) v11(32.53,82.58) v11(32.46,19.76) v11(32.46,19.31) v11(32.48,18.82) v11(32.51,13.62) v11(32.66,24.79) v11(32.66,16.87) v11(32.83,35.73) v11(32.83,34.23) v11(32.76,32.06) v11(32.79,28.35) v11(32.81,17.27) v11(32.79,15.01) v11(32.92,19.81) v11(32.94,19.33) v11(32.94,18.82) v11(32.96,35.12) v11(33.09,81.59) v11(33.09,42.19) v11(33.14,16.89) v11(33.17,81.09) v11(33.22,17.27) v11(33.3,65.4) v11(33.3,64.07) v11(33.3,44.1) v11(33.3,26.19) v11(33.37,19.53) v11(33.37,18.82) v11(33.42,14.89) v11(33.68,83.67) v11(33.68,47.02) v11(33.73,42.88) v11(33.74,17.21) v11(33.8,82.58) v11(33.78,19.25) v11(33.8,18.82) v11(33.8,13.62) v11(33.93,23.05) v11(34.01,81.61) v11(34.06,81.09) v11(34.06,28.35) v11(34.06,14.89) v11(34.19,48.54) v11(34.31,44.1) v11(34.33,37.23) v11(34.31,26.19) v11(34.26,18.82) v11(34.34,17.02) v11(34.34,16.64) v11(34.4,24.92) v11(34.41,19.25) v11(34.46,38.12) v11(34.55,17.47) v11(34.67,18.75) v11(34.72,17.02) v11(34.69,14.89) v11(34.79,42.17) v11(34.77,16.64) v11(34.95,83.64) v11(34.9,81.61) v11(34.95,65.4) v11(34.95,64.07) v11(34.95,47.02) v11(35.05,10.82) v11(35.07,82.58) v11(35.07,48.54) v11(35.07,36.17) v11(35.1,19.15) v11(35.14,18.14) v11(35.14,17.37) v11(35.07,13.62) v11(35.15,29.64) v11(35.15,18.72) v11(35.33,38.23) v11(35.33,28.35) v11(35.46,44.1) v11(35.46,39.12) v11(35.46,26.19) v11(35.46,16.64) v11(35.61,18.9) v11(35.56,17.04) v11(35.68,31.29) v11(35.75,20.85) v11(35.75,19.97) v11(35.68,18.44) v11(35.76,81.61) v11(35.84,81.09) v11(35.81,42.88) v11(35.83,35.73) v11(35.94,17.04) v11(35.96,48.54) v11(36.06,83.75) v11(36.06,16.69) v11(36.22,47.02) v11(36.17,18.44) v11(36.34,82.58) v11(36.34,13.62) v11(36.42,17.04) v11(36.47,44.1) v11(36.55,28.35) v11(36.5,18.75) v11(36.6,65.4) v11(36.6,64.07) v11(36.7,81.59) v11(36.73,81.09) v11(36.73,26.19) v11(36.67,18.42) v11(36.7,16.69) v11(36.83,36.73) v11(36.78,19.86) v11(36.8,17.04) v11(36.78,10.8) v11(36.85,48.54) v11(36.96,37.62) v11(36.98,24.79) v11(36.98,19.31) v11(36.98,18.77) v11(37.11,42.14) v11(37.06,30.71) v11(37.18,32.01) v11(37.21,16.77) v11(37.33,29.67) v11(37.28,25.17) v11(37.28,23.14) v11(37.28,22.68) v11(37.26,22.23) v11(37.28,21.01) v11(37.28,20.5) v11(37.26,19.99) v11(37.41,83.67) v11(37.49,82.58) v11(37.49,47.02) v11(37.49,44.1) v11(37.49,18.93) v11(37.59,81.59) v11(37.61,81.09) v11(37.61,15.23) v11(37.61,13.62) v11(37.74,48.54) v11(37.74,28.35) v11(37.69,25.27) v11(37.69,24.84) v11(37.69,24.41) v11(37.69,23.98) v11(37.69,23.57) v11(37.69,23.09) v11(37.69,22.63) v11(37.69,22.2) v11(37.69,21.77) v11(37.69,21.31) v11(37.69,20.85) v11(37.66,20.4) v11(37.72,16.77) v11(37.83,35.23) v11(37.87,26.19) v11(38.12,65.4) v11(38.12,64.07) v11(38.1,42.19) v11(38.1,25.25) v11(38.1,24.87) v11(38.53,81.61) v11(38.5,81.09) v11(38.5,44.1) v11(38.53,25.25) v11(38.53,24.87) v11(38.5,15.23) v11(38.63,48.54) v11(38.63,31.17) v11(38.66,83.57) v11(38.66,32.21) v11(38.76,82.58) v11(38.76,47.02) v11(38.88,28.35) v11(38.93,17.45) v11(38.88,16.99) v11(38.91,16.56) v11(38.88,13.62) v11(39.01,26.19) v11(38.96,25.3) v11(38.96,24.87) v11(39.01,15.57) v11(39.06,17.88) v11(39.06,16.11) v11(39.24,21.62) v11(39.24,21.11) v11(39.24,20.65) v11(39.24,20.19) v11(39.24,19.74) v11(39.16,19.36) v11(39.16,18.9) v11(39.16,18.37) v11(39.32,30.3) v11(39.31,23.49) v11(39.27,22.99) v11(39.3,22.25) v11(39.34,17.48) v11(39.34,17.04) v11(39.32,16.49) v11(39.44,31.68) v11(39.52,25.2) v11(39.52,24.79) v11(39.49,15.7) v11(39.65,42.14) v11(39.65,21.06) v11(39.62,19) v11(39.65,18.39) v11(39.6,17.91) v11(39.7,38.41) v11(39.67,21.62) v11(39.67,20.47) v11(39.7,19.81) v11(39.85,40.01) v11(39.93,25.12) v11(39.93,24.79) v11(39.9,24.03) v11(39.9,23.39) v11(40.03,82.58) v11(40.03,47.02) v11(40.03,13.62) v11(40.13,83.67) v11(40.18,33.89) v11(40.2,29.74) v11(40.15,28.35) v11(40.15,26.19) v11(40.28,23.06) v11(40.36,35.46) v11(40.38,25.1) v11(40.41,24.74) v11(40.36,3.58) v11(40.48,22.76) v11(40.64,23.06) v11(40.74,24.94) v11(40.79,54.54) v11(40.76,24.54) v11(40.89,56.44) v11(40.92,52.58) v11(41.04,60.38) v11(41.02,58.35) v11(41.04,39.75) v11(40.97,1.7) v11(41.07,37.64) v11(41.17,82.58) v11(41.25,28.35) v11(41.17,23.09) v11(41.2,22.68) v11(41.3,47.02) v11(41.3,44.98) v11(41.3,26.19) v11(41.35,24.94) v11(41.32,24.51) v11(41.27,22.02) v11(41.3,21.36) v11(41.32,20.35) v11(41.3,19.33) v11(41.3,17.93) v11(41.3,16.66) v11(41.3,15.14) v11(41.3,13.74) v11(41.44,66.57) v11(41.44,65.81) v11(41.44,63.02) v11(41.44,61.24) v11(41.37,36.58) v11(41.47,83.59) v11(41.63,81.48) v11(41.68,23.09) v11(41.81,70.24) v11(41.81,69.1) v11(41.78,60.45) v11(41.81,58.05) v11(41.81,43.97) v11(41.81,24.94) v11(41.78,24.51) v11(41.75,22.71) v11(42.31,24.51) v11(42.26,23.09) v11(42.34,22.68) v11(42.44,82.58) v11(42.36,24.94) v11(42.36,3.74) v11(42.57,47.02) v11(42.62,23.09) v11(42.64,19.48) v11(42.62,17.45) v11(42.82,44.98) v11(42.85,29.95) v11(42.82,28.35) v11(42.85,25) v11(42.82,24.51) v11(42.95,83.62) v11(42.95,6) v11(42.95,4.98) v11(42.97,80.65) v11(43.02,23.09) v11(42.97,22.66) v11(43.02,22.2) v11(43.08,21.11) v11(43.13,20.07) v11(43.2,19.2) v11(43.2,18.7) v11(43.2,18.06) v11(43.3,81.46) v11(43.3,25) v11(43.25,24.51) v11(43.41,35.18) v11(43.41,21.34) v11(43.41,20.83) v11(43.41,20.32) v11(43.43,19.81) v11(43.46,43.84) v11(43.46,42.37) v11(43.46,37.42) v11(43.46,23.06) v11(43.46,22.61) v11(43.46,22.2) v11(43.46,21.77) v11(43.53,17.65) v11(43.71,82.7) v11(43.71,25.05) v11(43.74,24.51) v11(43.84,47.02) v11(43.89,17.15) v11(44.24,25.15) v11(44.22,24.58) v11(44.22,17.72) v11(44.47,28.35) v11(44.6,82.83) v11(44.59,70.1) v11(44.6,44.86) v11(44.6,43.84) v11(44.6,42.57) v11(44.6,41.3) v11(44.6,36.98) v11(44.57,35.82) v11(44.6,34.44) v11(44.62,32.44) v11(44.6,31.52) v11(44.6,30.51) v11(44.6,29.36) v11(44.75,24.51) v11(44.83,17.6) v11(44.93,25.05) v11(44.98,24.11) v11(44.98,23.6) v11(44.98,23.12) v11(44.98,22.66) v11(44.98,22.2) v11(44.98,21.69) v11(45.02,20.98) v11(44.98,20.37) v11(44.98,19.89) v11(45.08,80.62) v11(45.11,47.02) v11(45.13,24.66) v11(45.11,19.2) v11(45.11,18.7) v11(45.11,18.06) v11(45.16,83.75) v11(45.15,67.27) v11(45.15,65.58) v11(45.34,24.11) v11(45.31,23.09) v11(45.31,22.63) v11(45.34,21.69) v11(45.44,70.39) v11(45.44,67.56) v11(45.44,66.99) v11(45.44,65.86) v11(45.36,23.6) v11(45.36,22.15) v11(45.41,20.27) v11(45.39,19.81) v11(45.62,45.49) v11(45.72,67.27) v11(45.72,66.14) v11(45.72,65.58) v11(45.87,82.7) v11(46,67.56) v11(46.05,34.6) v11(46.07,81.31) v11(46.2,79.05) v11(46.22,43.16) v11(46.28,69.54) v11(46.38,47.02) v11(46.57,68.69) v11(46.57,67.56) v11(46.58,33.17) v11(46.85,69.54) v11(46.89,43.21) v11(47.01,82.7) v11(47.42,70.1) v11(47.4,68.45) v11(47.4,67.5) v11(47.4,66.54) v11(47.4,65.59) v11(47.4,61.78) v11(47.4,60.83) v11(47.4,59.87) v11(47.55,43.44) v11(47.65,47.02) v11(47.65,41.07) v11(47.72,79.07) v11(47.67,77.55) v11(47.7,70.39) v11(47.7,69.26) v11(47.67,67.02) v11(47.67,60.35) v11(47.67,37.95) v11(47.88,81.38) v11(47.95,67.5) v11(47.95,59.87) v11(47.9,45.49) v11(47.9,33.17) v11(47.98,70.1) v11(48.22,67.02) v11(48.22,61.3) v11(48.22,60.35) v11(48.5,67.5) v11(48.5,66.54) v11(48.5,65.59) v11(48.5,64.64) v11(48.5,63.69) v11(48.5,62.73) v11(48.5,61.78) v11(48.5,60.83) v11(48.5,59.87) v11(48.61,39.8) v11(48.71,83.54) v11(48.65,40.54) v11(48.83,70.39) v11(48.83,69.82) v11(48.83,69.26) v11(48.77,67.02) v11(48.77,66.07) v11(48.77,65.11) v11(48.77,64.16) v11(48.77,63.21) v11(48.77,62.26) v11(48.77,60.35) v11(48.82,49.2) v11(48.92,82.83) v11(48.92,53.89) v11(48.92,47.02) v11(49.05,66.54) v11(49.05,65.59) v11(49.05,63.69) v11(49.05,62.73) v11(48.99,41.3) v11(49.11,70.67) v11(49.11,70.1) v11(49.32,81.41) v11(49.32,63.21) v11(49.32,62.26) v11(49.4,70.39) v11(49.43,44.98) v11(49.37,33.15) v11(49.58,79.2) v11(49.6,68.45) v11(49.6,67.5) v11(49.6,66.54) v11(49.6,65.59) v11(49.6,63.69) v11(49.81,82.7) v11(49.87,65.11) v11(49.87,61.3) v11(49.98,73) v11(49.98,72.67) v11(50.19,53.93) v11(50.19,47.02) v11(50.44,52.55) v11(50.42,41.28) v11(50.52,43.18) v11(50.45,40.54) v11(50.47,39.7) v11(50.7,68.45) v11(50.7,67.5) v11(50.7,63.69) v11(50.7,60.83) v11(50.7,59.87) v11(50.72,33.17) v11(50.97,67.02) v11(50.97,62.26) v11(50.97,61.3) v11(51,44.98) v11(51.36,37.67) v11(51.52,65.11) v11(51.52,62.26) v11(51.52,61.3) v11(51.46,47.02) v11(51.56,78.13) v11(51.58,49.09) v11(51.66,77.37) v11(51.66,58.5) v11(51.84,82.83) v11(51.8,66.54) v11(51.8,64.64) v11(51.8,62.73) v11(51.8,60.83) v11(51.94,33.17) v11(52.07,67.97) v11(52.07,67.02) v11(52.07,66.07) v11(52.07,65.11) v11(52.07,64.16) v11(52.07,63.21) v11(52.19,41.3) v11(52.24,39.8) v11(52.35,67.5) v11(52.35,66.54) v11(52.35,63.69) v11(52.27,43.18) v11(52.25,40.54) v11(52.55,81.54) v11(52.51,58.22) v11(52.51,57.65) v11(52.62,67.97) v11(52.62,67.02) v11(52.62,61.3) v11(52.6,47.02) v11(52.65,78.11) v11(52.75,44.98) v11(52.85,74.78) v11(52.9,62.73) v11(52.98,33.15) v11(53.09,82.98) v11(53.17,67.97) v11(53.17,66.07) v11(53.17,64.16) v11(53.36,82.45) v11(53.36,70.39) v11(53.45,66.54) v11(53.45,65.59) v11(53.45,64.64) v11(53.45,63.69) v11(53.45,61.78) v11(53.57,74.93) v11(53.64,70.1) v11(53.92,70.39) v11(54,44.93) v11(54,43.13) v11(54.02,41.4) v11(54,33.15) v11(54.05,40.54) v11(54.27,67.97) v11(54.51,84.05) v11(54.51,82.58) v11(54.55,67.5) v11(54.62,54.38) v11(54.73,82) v11(54.82,67.02) v11(54.82,66.07) v11(54.82,65.11) v11(54.82,61.3) v11(54.82,60.35) v11(54.77,58.22) v11(54.77,57.65) v11(55.01,33.15) v11(55.1,67.5) v11(55.1,65.59) v11(55.1,64.64) v11(55.1,61.78) v11(55.1,60.83) v11(55.06,57.94) v11(55.19,78.13) v11(55.27,81.81) v11(55.34,58.22) v11(55.37,67.97) v11(55.37,67.02) v11(55.37,62.26) v11(55.37,61.3) v11(55.52,46.76) v11(55.65,67.5) v11(55.65,66.54) v11(55.65,64.64) v11(55.65,62.73) v11(55.65,59.87) v11(55.65,39.6) v11(55.7,83.36) v11(55.72,44.96) v11(55.79,73.94) v11(55.78,43.08) v11(55.92,67.02) v11(55.92,66.07) v11(55.92,61.3) v11(55.85,41.23) v11(55.85,40.54) v11(56.03,33.15) v11(56.18,79.25) v11(56.79,44.98) v11(57.05,79.91) v11(57.05,33.15) v11(57.2,39.55) v11(57.4,78.34) v11(57.6,63.31) v11(58.01,44.96) v11(58.06,43.97) v11(58.11,41.66) v11(58.06,33.15) v11(58.21,42.67) v11(58.71,74.32) v11(58.82,50.83) v11(58.89,75.72) v11(59.08,33.15) v11(59.18,35.76) v11(59.36,42.55) v11(59.71,74.8) v11(59.66,69.26) v11(59.71,46.76) v11(60.09,33.15) v11(60.4,41.4) v11(60.47,72.8) v11(60.93,74.2) v11(60.98,73.56) v11(61.03,72.01) v11(61.11,33.15) v11(61.49,63.92) v11(61.49,62.78) v11(61.49,60.87) v11(61.49,59.73) v11(61.49,58.59) v11(61.62,74.02) v11(61.87,46.76) v11(61.98,70.21) v11(61.98,68.86) v11(61.98,68.1) v11(61.98,67.21) v11(61.98,66.45) v11(61.98,65.05) v11(62.11,75.72) v11(62.13,33.15) v11(62.25,58.57) v11(62.35,35.18) v11(62.51,79.66) v11(62.48,75.9) v11(62.51,74.21) v11(62.68,46.76) v11(62.91,41.17) v11(63.14,33.15) v11(63.38,69.75) v11(63.73,44.5) v11(63.7,43.92) v11(63.73,42.72) v11(63.8,78.11) v11(63.82,71.65) v11(63.82,70.77) v11(63.82,67.34) v11(63.83,66.45) v11(63.78,46.76) v11(63.75,45.01) v11(63.9,64.4) v11(63.9,60.86) v11(64.03,63.26) v11(64.03,61.38) v11(64.03,35.59) v11(64.11,83.39) v11(64.16,33.15) v11(64.41,78.03) v11(64.67,81.81) v11(64.84,64.29) v11(64.79,46.76) v11(64.94,84.08) v11(64.87,63.43) v11(64.94,60.02) v11(64.96,71.63) v11(65.17,79.66) v11(65.17,73.85) v11(65.17,33.15) v11(65.33,64.31) v11(65.33,63.45) v11(65.38,76.94) v11(65.43,52.38) v11(65.78,66.42) v11(65.94,46.51) v11(65.94,45.24) v11(65.94,43.97) v11(65.94,42.7) v11(65.94,41.43) v11(65.94,40.16) v11(65.94,38.89) v11(65.94,37.62) v11(65.94,36.35) v11(65.94,35.08) v11(66.19,33.15) v11(66.29,53.49) v11(66.49,62.13) v11(66.52,61.32) v11(66.62,83.64) v11(66.57,80.04) v11(66.85,76.05) v11(66.98,78.31) v11(67.03,61.29) v11(67.05,62.13) v11(67.1,36.6) v11(67.21,33.15) v11(67.76,84.63) v11(67.97,62.16) v11(68.2,78.39) v11(68.2,61.22) v11(68.22,33.15) v11(68.91,35.03) v11(69.14,76.99) v11(69.14,75.97) v11(69.24,33.15) v11(69.64,78.44) v11(70.2,82.3) v11(70.2,46.53) v11(70.2,45.8) v11(70.18,42.44) v11(70.18,41.68) v11(70.15,40.13) v11(70.18,39.73) v11(70.3,84.66) v11(70.25,33.15) v11(70.35,44.6) v11(70.35,44.27) v11(70.56,75.87) v11(70.58,46.53) v11(70.56,45.8) v11(70.63,42.42) v11(70.61,41.66) v11(70.61,40.13) v11(70.63,39.73) v11(70.86,44.6) v11(70.86,44.27) v11(71.02,48.26) v11(71.24,78.31) v11(71.35,81.13) v11(71.27,33.15) v11(72.29,33.15) v11(72.41,77.04) v11(72.41,44.86) v11(72.41,44.35) v11(72.92,44.86) v11(72.92,44.35) v11(73.02,33.15) v11(73.2,81.36) v11(73.28,78.31) v11(73.38,86.56) v11(73.43,44.86) v11(73.43,44.35) v11(73.66,84.38) v11(73.68,73.08) v11(73.68,72.49) v11(73.78,77.01) v11(74.04,33.15) v11(74.14,73.08) v11(74.14,72.52) v11(74.39,65.05) v11(74.39,64.59) v11(74.44,63.37) v11(74.39,62.46) v11(74.42,53.95) v11(74.39,53.52) v11(74.39,53.09) v11(74.7,73.1) v11(74.7,72.52) v11(74.85,83.11) v11(74.93,65.05) v11(74.88,53.95) v11(74.88,53.52) v11(74.88,53.09) v11(74.95,64.57) v11(75.02,63.4) v11(74.98,62.46) v11(75.13,77.07) v11(75.05,33.15) v11(75.18,49.33) v11(75.21,48.85) v11(75.18,44.98) v11(75.18,44.55) v11(75.54,81.33) v11(75.49,78.31) v11(75.59,44.98) v11(75.59,44.48) v11(75.69,73.08) v11(75.71,72.47) v11(75.66,49.35) v11(75.66,48.82) v11(75.82,86.62) v11(75.79,84.81) v11(75.97,44.98) v11(75.97,44.48) v11(76.07,33.15) v11(76.2,72.49) v11(76.22,71.07) v11(76.22,70.46) v11(76.2,65.23) v11(76.22,64.8) v11(76.18,63.5) v11(76.35,60.68) v11(76.32,60.22) v11(76.35,55.45) v11(76.35,55.04) v11(76.3,53.82) v11(76.27,53.37) v11(76.54,63.5) v11(76.58,65.23) v11(76.73,73.08) v11(76.73,72.49) v11(76.7,71.07) v11(76.7,70.46) v11(76.73,60.49) v11(76.68,55.48) v11(76.68,55.04) v11(76.73,53.82) v11(76.73,53.34) v11(76.86,77.01) v11(76.93,65.23) v11(76.86,64.8) v11(76.92,63.5) v11(77.14,60.73) v11(77.14,60.2) v11(77.06,55.45) v11(77.06,55.04) v11(77.11,53.8) v11(77.14,53.34) v11(77.09,33.15) v11(77.19,78.31) v11(77.21,71.07) v11(77.21,70.49) v11(77.26,65.23) v11(77.28,63.5) v11(77.37,48.29) v11(77.73,63.47) v11(77.9,81.05) v11(78.1,33.15) v11(78.17,63.49) v11(78.33,55.83) v11(78.33,54.87) v11(78.41,71.35) v11(78.41,70.66) v11(78.38,65.41) v11(78.41,49.91) v11(78.41,49.1) v11(78.46,60.61) v11(78.71,55.83) v11(78.71,54.87) v11(78.81,70.66) v11(78.81,49.91) v11(78.79,49.1) v11(78.86,71.32) v11(79.12,33.15) v11(79.65,84.56) v11(80.01,82.15) v11(80.13,33.15) v11(80.87,53.77) v11(81.1,81.05) v11(81.15,33.15) v11(81.3,53.77) v11(81.63,82.17) v11(81.76,53.75) v11(81.78,49.86) v11(81.81,49.23) v11(81.94,44.56) v11(81.9,38.63) v11(82.17,33.15) v11(82.34,84.25) v11(82.32,49.86) v11(82.29,49.23) v11(82.8,80.9) v11(82.85,73.23) v11(82.9,72.65) v11(83.23,82.96) v11(83.15,43.53) v11(83.18,33.15) v11(83.31,73.23) v11(83.36,72.65) v11(83.54,71.4) v11(83.51,57.15) v11(83.56,70.87) v11(83.56,70.38) v11(83.61,55.4) v11(83.59,54.97) v11(83.82,73.23) v11(83.84,72.65) v11(83.97,71.4) v11(83.97,70.87) v11(83.97,70.38) v11(84.02,55.32) v11(83.99,54.94) v11(84.2,33.15) v11(84.4,81.56) v11(84.53,37.63) v11(84.88,57.63) v11(84.88,57.25) v11(85.06,83.42) v11(85.21,71.4) v11(85.24,70.33) v11(85.16,52.91) v11(85.21,52) v11(85.19,50.78) v11(85.21,33.15) v11(85.29,80.8) v11(85.26,68.43) v11(85.47,68.15) v11(85.54,50.45) v11(85.62,52.91) v11(85.62,51.64) v11(85.55,44.48) v11(85.62,42.23) v11(85.8,71.4) v11(85.77,70.33) v11(86.23,33.15) v11(86.29,35.59) v11(86.26,34.06) v11(86.51,49.63) v11(86.51,42.23) v11(86.74,76.91) v11(87.12,80.95) v11(87.17,82.93) v11(87.25,33.15) v11(87.4,42.23) v11(87.53,34.06) v11(87.63,60.5) v11(87.63,60.15) v11(87.69,45.49) v11(87.96,40.21) v11(88.13,49.86) v11(88.16,48.46) v11(88.26,33.15) v11(88.46,80.98) v11(88.49,57.66) v11(88.49,57.2) v11(88.64,47.55) v11(88.57,39.14) v11(88.57,38.76) v11(88.59,38.38) v11(88.59,38) v11(88.69,50.34) v11(88.77,57.43) v11(88.8,34.06) v11(88.92,39.14) v11(88.92,38.76) v11(88.92,38.38) v11(88.92,38) v11(89.05,57.66) v11(89.05,57.2) v11(89.13,40.57) v11(89.2,82.78) v11(89.33,73.61) v11(89.3,69.04) v11(89.33,68.68) v11(89.3,39.14) v11(89.3,38.76) v11(89.3,38.38) v11(89.3,38) v11(89.28,33.15) v11(89.76,69.04) v11(89.76,68.66) v11(89.79,59.39) v11(89.86,63.68) v11(89.96,73.23) v11(90.01,72.75) v11(90.04,56.64) v11(90.04,52.48) v11(90.01,51.51) v11(90.04,50.29) v11(90.04,49.84) v11(90.01,49.35) v11(90.01,48.13) v11(90.04,47.68) v11(90.04,47.17) v11(90.07,34.06) v11(90.19,59.39) v11(90.27,63.68) v11(90.29,33.15) v11(90.62,73.23) v11(90.6,72.75) v11(90.6,54.21) v11(90.6,53.77) v11(90.65,52.48) v11(90.62,51.51) v11(90.62,50.29) v11(90.6,49.84) v11(90.62,49.35) v11(90.62,48.13) v11(90.6,47.65) v11(90.62,47.14) v11(90.93,81.94) v11(91.13,64.06) v11(91.13,63.73) v11(91.21,34.06) v11(91.34,54.21) v11(91.34,53.77) v11(91.28,39.22) v11(91.31,33.15) v11(91.36,81.1) v11(91.51,64.06) v11(91.51,63.73) v11(91.72,79.78) v11(91.82,71.27) v11(91.84,47.65) v11(92.17,71.73) v11(92.2,38.18) v11(92.25,35.82) v11(92.33,33.15) v11(92.38,53.57) v11(92.4,53.19) v11(92.38,52.27) v11(92.38,51.92) v11(92.48,82.93) v11(92.48,34.06) v11(92.55,78.46) v11(92.64,50.19) v11(92.62,49.33) v11(92.86,79.78) v11(92.88,53.57) v11(92.88,53.19) v11(92.86,52.27) v11(92.86,51.92) v11(93.21,71.63) v11(93.32,74.27) v11(93.27,72.24) v11(93.34,33.15) v11(93.47,67.9) v11(93.49,48.41) v11(93.72,75.34) v11(93.75,74.83) v11(93.7,73.81) v11(93.7,73.28) v11(93.7,72.8) v11(93.75,40.12) v11(93.75,34.06) v11(93.77,84.63) v11(93.85,58.4) v11(93.85,58.02) v11(93.85,57.25) v11(93.85,56.87) v11(93.85,56.11) v11(93.85,55.7) v11(93.88,81.05) v11(94.13,79.78) v11(94.21,37.75) v11(94.23,37.29) v11(94.31,75.36) v11(94.33,74.86) v11(94.31,73.79) v11(94.33,73.38) v11(94.33,72.82) v11(94.33,57.25) v11(94.33,56.87) v11(94.43,61.34) v11(94.43,59.59) v11(94.36,58.4) v11(94.36,58.02) v11(94.36,56.11) v11(94.36,55.7) v11(94.36,33.15) v11(94.56,37.75) v11(94.56,37.29) v11(95.02,34.06) v11(95.12,64.03) v11(95.35,78.28) v11(95.3,35.46) v11(95.4,79.78) v11(95.37,33.15) v11(95.53,38.23) v11(95.53,36.43) v11(95.75,63.35) v11(96.16,34.06) v11(96.34,37.29) v11(96.39,33.15) v11(96.47,78.34) v11(96.49,64.16) v11(96.59,72.29) v11(96.64,70.18) v11(96.64,68.28) v11(96.67,79.78) v11(96.67,73.97) v11(96.85,62.08) v11(96.9,59.89) v11(97.13,72.87) v11(97.13,67.39) v11(97.13,53.06) v11(97.23,75.36) v11(97.2,74.93) v11(97.15,73.76) v11(97.23,71.73) v11(97.2,71.05) v11(97.18,69.6) v11(97.18,68.94) v11(97.15,66.7) v11(97.15,59.41) v11(97.15,59.01) v11(97.15,58.14) v11(97.15,57.74) v11(97.15,56.87) v11(97.15,56.47) v11(97.15,55.6) v11(97.15,55.17) v11(97.15,54.33) v11(97.15,53.93) v11(97.15,52.66) v11(97.15,51.82) v11(97.15,51.39) v11(97.41,33.15) v11(97.51,73.71) v11(97.51,72.87) v11(97.53,67.59) v11(97.53,66.91) v11(97.61,75.24) v11(97.61,74.86) v11(97.58,71.71) v11(97.58,71.05) v11(97.56,69.6) v11(97.56,68.94) v11(97.66,59.41) v11(97.66,59.01) v11(97.66,58.14) v11(97.66,57.74) v11(97.66,56.87) v11(97.66,56.47) v11(97.66,55.6) v11(97.66,55.2) v11(97.66,54.33) v11(97.66,53.93) v11(97.66,53.09) v11(97.66,52.66) v11(97.66,51.82) v11(97.66,51.39) v11(97.94,79.78) v11(98.07,34.06) v11(98.19,42.75) v11(98.42,33.15) v11(98.52,57.61) v11(98.52,57.1) v11(98.52,56.59) v11(98.47,36.55) v11(98.47,35.36) v11(98.62,37.64) v11(98.83,39.02) v11(98.98,44.98) v11(98.96,37.59) v11(99.13,35.36) v11(99.21,79.78) v11(99.18,57.61) v11(99.16,57.1) v11(99.18,56.57) v11(99.16,36.55) v11(99.34,38.43) v11(99.34,34.06) v11(99.44,33.15) v11(99.56,61.49) v11(99.79,36.55) v11(99.79,35.38) v11(99.92,76.51) v11(99.95,75.74) v11(99.92,74.91) v11(100.02,59.89) v11(100.1,58.8) v11(100.15,39.17) v11(100.23,44.73) v11(100.33,58.55) v11(100.28,58.14) v11(100.38,59.39) v11(100.43,36.55) v11(100.43,35.41) v11(100.48,79.78) v11(100.45,33.15) v11(100.61,34.06) v11(100.81,77.37) v11(100.83,75.8) v11(100.81,74.88) v11(100.86,76.51) v11(101.34,60.5) v11(101.47,60.1) v11(101.47,33.15) v11(101.62,79.78) v11(101.75,82.83) v11(101.75,42.72) v11(101.8,78.31) v11(101.93,46.97) v11(101.88,34.06) v11(102.1,36.15) v11(102.49,45.47) v11(102.49,33.15) v11(102.82,85.09) v11(102.82,82.15) v11(102.82,50.19) v11(102.89,79.78) v11(102.89,78.87) v11(102.92,60.05) v11(103.02,66.19) v11(103.02,34.06) v11(103.2,80.9) v11(103.2,44.81) v11(103.27,38.89) v11(103.37,33.15) v11(103.65,82.6) v11(103.81,56.47) v11(103.91,79.78) v11(104.04,65.41) v11(104.04,42.44) v11(104.21,46.36) v11(104.16,34.06) v11(104.57,43.79) v11(104.67,83.72) v11(104.77,81.26) v11(104.8,45.9) v11(104.92,79.78) v11(104.92,67.55) v11(105.1,64.34) v11(105.2,66.42) v11(105.18,39.65) v11(105.18,38.38) v11(105.18,37.11) v11(105.18,35.84) v11(105.18,34.32) v11(105.64,82.78) v11(105.56,40.79) v11(105.74,85.14) v11(106.07,79.78) v11(106.23,73.43) v11(106.3,72.04) v11(106.3,71.53) v11(106.3,71.02) v11(106.3,70.51) v11(106.3,70) v11(106.32,46.46) v11(106.7,42.19) v11(106.81,72.04) v11(106.81,71.53) v11(106.81,71.02) v11(106.81,70.51) v11(106.81,70) v11(106.78,68.73) v11(106.8,68.15) v11(106.78,67.69) v11(106.83,66.7) v11(106.83,66.19) v11(106.83,65.69) v11(106.78,39.24) v11(107.08,79.78) v11(107.08,40.79) v11(107.21,66.7) v11(107.25,61.37) v11(107.21,46.46) v11(107.34,83.59) v11(107.29,75.74) v11(107.32,72.04) v11(107.32,71.53) v11(107.32,71.02) v11(107.32,70.51) v11(107.32,70) v11(107.34,68.73) v11(107.34,67.97) v11(107.34,66.19) v11(107.34,65.69) v11(107.31,37.9) v11(107.39,74.86) v11(107.64,82.68) v11(107.85,79.78) v11(107.79,65.18) v11(107.92,75.74) v11(107.97,74.83) v11(108.05,38.84) v11(108.2,81.23) v11(108.41,68.48) v11(108.35,40.79) v11(108.46,70.51) v11(108.48,65.94) v11(108.84,69.17) v11(108.76,52.96) v11(108.86,79.78) v11(109.04,39.14) v11(109.5,74.83) v11(109.75,40.79) v11(109.9,72.44) v11(110,83.21) v11(110,81.94) v11(110,80.8) v11(110,79.78) v11(109.98,71.35) v11(110.13,76.23) v11(110.13,75.34) v11(110.09,66.96) v11(110.25,73.1) v11(110.26,64.81) v11(110.49,85.14) v11(110.64,83.85) v11(110.64,70.51) v11(110.89,72.29) v11(111.02,77.75) v11(110.99,67.92) v11(111.02,56.95) v11(111.02,40.79) v11(111.15,65.29) v11(111.1,54.97) v11(111.4,85.24) v11(111.4,75.08) v11(111.4,73.94) v11(111.53,77.5) v11(111.5,76.53) v11(111.5,76.15) v11(111.53,68.61) v11(111.73,69.19) v11(111.78,82.55) v11(111.78,72.29) v11(111.91,83.85) v11(112.09,66.68) v11(112.16,62.51) v11(112.16,61.49) v11(112.16,60.73) v11(112.16,59.59) v11(112.16,58.7) v11(112.16,57.68) v11(112.16,56.54) v11(112.16,55.53) v11(112.16,54.51) v11(112.16,53.37) v11(112.16,52.48) v11(112.16,51.46) v11(112.16,50.45) v11(112.16,49.3) v11(112.16,48.03) v11(112.16,46.76) v11(112.16,45.75) v11(112.16,44.48) v11(112.16,43.21) v11(112.16,41.94) v11(112.16,40.79) v11(112.3,77.25) v11(112.29,73.94) v11(112.29,67.34) v11(112.29,64.92) v11(112.62,81.87) v11(112.62,81.51) v11(112.62,38.28) v11(112.72,37.31) v11(112.8,66.7) v11(112.89,74.85) v11(113.03,77.37) v11(113.1,56.64) v11(113.18,83.85) v11(113.23,82.53) v11(113.18,81.87) v11(113.18,81.51) v11(113.18,65.3) v11(113.33,85.14) v11(113.31,64.92) v11(113.36,55.53) v11(113.36,55.04) v11(113.64,34.22) v11(113.74,81.51) v11(113.69,66.7) v11(113.76,36.6) v11(114.07,63.27) v11(114.45,83.85) v11(114.47,78.46) v11(114.63,82.58) v11(114.58,77.5) v11(114.58,66.7) v11(114.58,37.47) v11(114.86,34.37) v11(114.96,63.27) v11(115.1,80.42) v11(115.08,79.81) v11(115.13,79.4) v11(115.06,56.34) v11(115.34,61.27) v11(115.47,83.85) v11(115.52,82.61) v11(115.47,66.7) v11(115.47,61.85) v11(115.62,48.87) v11(115.62,47.7) v11(115.57,46.05) v11(115.82,55.42) v11(115.82,42.83) v11(115.9,59.84) v11(115.97,73.03) v11(116.05,71.88) v11(115.97,63.27) v11(116.07,71.07) v11(116.07,58.95) v11(116.3,85.17) v11(116.35,66.7) v11(116.43,52.3) v11(116.38,37.9) v11(116.53,49.71) v11(116.61,47.6) v11(116.74,83.85) v11(116.71,41.86) v11(116.66,41.2) v11(116.71,39.27) v11(116.86,63.27) v11(117.04,71.91) v11(116.99,56.34) v11(117.01,50.93) v11(117.09,73) v11(117.09,71.12) v11(117.14,45.77) v11(117.14,43.56) v11(117.24,81.55) v11(117.24,66.7) v11(117.34,83.81) v11(117.32,37.11) v11(117.41,56.92) v11(117.85,71.96) v11(117.9,71.15) v11(117.88,63.27) v11(117.93,55.55) v11(118.01,83.85) v11(118.18,39.37) v11(118.31,49.89) v11(118.39,72.98) v11(118.5,83.83) v11(118.49,51.16) v11(118.72,58.24) v11(118.72,36.17) v11(118.72,35.36) v11(118.84,71.96) v11(118.84,71.12) v11(118.89,63.27) v11(118.89,56.26) v11(118.87,55.63) v11(119.02,83.85) v11(119.03,73.37) v11(119.12,85.17) v11(119.15,61.28) v11(119.12,46.1) v11(119.3,57.84) v11(119.47,35.76) v11(119.58,83.85) v11(119.73,52.38) v11(119.78,44.48) v11(119.91,82.36) v11(119.91,63.27) v11(119.94,34.32) v11(120.09,56.24) v11(120.06,55.63) v11(120.09,42.72) v11(120.24,36.17) v11(120.21,35.38) v11(120.29,83.85) v11(120.57,58.32) v11(120.75,63.04) v11(120.85,85.19) v11(120.8,82.36) v11(120.88,83.85) v11(121.08,38.48) v11(121.35,60.81) v11(121.26,49) v11(121.56,83.85) v11(121.56,56.82) v11(121.66,63.04) v11(121.76,36.4) v11(121.97,41.58) v11(122.12,57.68) v11(122.09,44.32) v11(122.22,83.87) v11(122.35,34.6) v11(122.45,64.94) v11(122.4,52.43) v11(122.68,63.04) v11(122.83,83.85) v11(122.96,60.48) v11(123.09,58.37) v11(123.26,83.85) v11(123.34,64.94) v11(123.69,83.82) v11(123.71,66.57) v11(123.8,82.86) v11(123.82,62.99) v11(123.85,61.81) v11(123.77,59.56) v11(123.85,57.3) v11(124.1,83.85) v11(124.09,65.81) v11(124.05,61.19) v11(124.56,57.63) v11(124.66,58.47) v11(124.99,63.27) v11(125.09,61.42) v11(125.24,83.85) v11(125.75,63.27) v11(125.78,56.49) v11(125.88,83.08) v11(125.88,82.07) v11(125.88,80.8) v11(125.88,69.37) v11(125.85,68.33) v11(125.88,67.08) v11(125.88,66.07) v11(125.88,65.18) v11(125.88,64.16) v11(125.9,60.81) v11(126.18,61.52) v11(126.62,69.19) v11(126.67,56.62) v11(126.84,69.9) v11(126.9,62.84) v11(126.95,61.65) v11(126.97,64.72) v11(127.12,59.64) v11(127.25,58.07) v11(127.91,71.35) v11(127.99,76.32) v11(128.04,60.1) v11(128.01,57.46) v11(128.27,79.35) v11(128.34,70.54) v11(128.42,84.23) v11(128.42,80.42) v11(128.44,55.27) v11(128.52,82.86) v11(128.5,68.35) v11(128.6,81.48) v11(128.8,66.02) v11(128.8,65) v11(128.8,63.98) v11(128.8,62.97) v11(128.8,61.95) v11(128.8,60.94) v11(128.8,59.92) v11(128.8,58.9) v11(128.8,57.89) v11(128.8,56.87) v11(128.8,55.86) v11(129.21,67.41) v11(129.69,79.33) v11(129.77,76.32) v11(129.94,69.78) v11(130.02,84.48) v11(130.32,80.7) v11(130.65,76.32) v11(130.78,71.12) v11(130.91,69.62) v11(130.91,69.04) v11(131.01,67.84) v11(131.39,82.55) v11(131.82,69.83) v11(131.92,79.17) v11(132.43,76.32) v11(132.53,84.2) v11(132.46,81.46) v11(132.58,68.3) v11(132.71,69.85) v11(133.45,79.2) v11(133.8,82.88) v11(134.26,79.22) v11(134.59,69.62) v11(134.57,69.01) v11(134.77,70.72) v11(135.23,80.93) v11(135.56,69.42) v11(135.71,84.86) v11(135.66,79.61) v11(136.22,82.81) v11(136.78,79.25) v11(136.93,69.85) v11(137.59,68.38) v11(137.67,70.44) v11(137.84,82.02) v11(137.99,67.57) v11(138.12,84) v11(138.3,80.32) v11(138.3,78.92) v11(138.45,80.77) v11(138.55,71.27) v11(138.6,70.11) v11(139.01,67.57) v11(139.09,78.06) v11(139.21,68.91) v11(139.52,84.63) v11(139.62,81.74) v11(139.7,83.19) v11(140.03,67.57) v11(140.43,71.15) v11(141.04,67.57) v11(141.17,69.93) v11(141.42,71.4) v11(141.83,85.45) v11(141.86,85.04) v11(142.06,67.57) v11(142.19,85.42) v11(142.21,84.91) v11(142.26,74.88) v11(142.26,74.32) v11(142.36,68.45) v11(142.52,83.82) v11(142.9,70.61) v11(143.02,86.16) v11(143.07,73.11) v11(143.07,67.57) v11(143.23,85.29) v11(143.25,84.91) v11(143.53,71.76) v11(143.63,84.99) v11(143.63,82.5) v11(143.66,85.32) v11(143.66,82.15) v11(143.76,74.88) v11(143.76,74.42) v11(144.04,85.32) v11(144.04,84.99) v11(143.99,82.5) v11(143.99,82.15) v11(144.09,67.57) v11(144.4,85.68) v11(144.45,85.32) v11(144.45,84.99) v11(144.4,82.48) v11(144.42,82.15) v11(144.52,68.4) v11(144.7,86.08) v11(144.8,85.32) v11(144.8,84.99) v11(144.78,82.5) v11(144.78,82.17) v11(145.13,82.5) v11(145.13,82.15) v11(145.11,67.57) v11(145.16,85.35) v11(145.18,84.96) v11(145.26,74.86) v11(145.26,74.42) v11(145.84,70.44) v11(146.12,67.57) v11(146.71,83.97) v11(146.71,82.7) v11(146.71,81.43) v11(146.71,80.16) v11(146.71,78.89) v11(146.71,77.62) v11(146.83,76.61) v11(146.96,85.62) v11(147.14,67.57) v11(147.34,85.65) v11(147.37,68.78) v11(147.52,71.32) v11(147.6,84.48) v11(148.1,76.61) v11(148.1,72.29) v11(148.15,86.16) v11(148.19,82.93) v11(148.19,82.04) v11(148.15,67.57) v11(148.49,85.62) v11(148.58,70.46) v11(148.74,68.48) v11(148.87,84.48) v11(149.25,68.73) v11(149.17,67.57) v11(149.32,69.39) v11(149.37,85.6) v11(149.37,76.61) v11(149.5,78.87) v11(149.68,73.08) v11(150.01,68.99) v11(150.14,84.48) v11(150.26,69.62) v11(150.54,86.18) v11(150.64,76.61) v11(150.64,70) v11(150.9,78) v11(151.33,68.33) v11(151.33,67.97) v11(151.33,67.64) v11(151.3,67.29) v11(151.33,66.96) v11(151.41,84.48) v11(151.39,69.01) v11(151.36,68.68) v11(151.46,69.34) v11(151.58,69.7) v11(151.71,70) v11(151.84,70.31) v11(151.79,66.65) v11(151.86,76.25) v11(151.86,74.98) v11(151.86,73.71) v11(151.89,73.05) v11(151.86,72.44) v11(152.04,84.51) v11(151.99,70.61) v11(152.14,66.65) v11(152.19,70.92) v11(152.42,71.2) v11(152.5,66.65) v11(152.68,84.48) v11(152.65,71.48) v11(152.8,68.91) v11(152.78,68.58) v11(152.78,68.25) v11(152.93,71.71) v11(152.85,69.24) v11(152.85,66.65) v11(152.98,69.55) v11(153.13,69.85) v11(153.11,68.25) v11(153.16,71.96) v11(153.21,66.65) v11(153.31,86.16) v11(153.26,84.69) v11(153.29,70.16) v11(153.26,69.14) v11(153.34,68.71) v11(153.41,72.19) v11(153.51,70.41) v11(153.57,66.65) v11(153.67,72.42) v11(153.67,68.38) v11(153.77,70.66) v11(153.95,86.13) v11(153.95,84.48) v11(153.92,66.65) v11(153.96,82.62) v11(153.96,79.02) v11(153.96,75.42) v11(153.96,74.52) v11(153.96,73.62) v11(153.96,72.72) v11(154,70.92) v11(154.02,68.38) v11(154.2,70) v11(154.28,72.39) v11(154.28,71.17) v11(154.28,66.65) v11(154.35,68.38) v11(154.53,71.43) v11(154.58,86.16) v11(154.56,72.14) v11(154.63,66.57) v11(154.71,68.48) v11(154.86,81.72) v11(154.86,74.52) v11(154.86,73.62) v11(154.86,72.72) v11(154.86,71.82) v11(154.99,66.6) v11(155.09,68.48) v11(155.22,84.48) v11(155.34,77.85) v11(155.34,70) v11(155.42,66.6) v11(155.47,68.45) v11(155.75,66.6) v11(155.76,74.52) v11(155.76,73.62) v11(155.76,72.72) v11(155.76,71.82) v11(155.85,68.51) v11(156.11,66.6) v11(156.23,70) v11(156.23,68.53) v11(156.49,84.48) v11(156.46,66.6) v11(156.66,82.62) v11(156.66,79.92) v11(156.66,75.42) v11(156.66,73.62) v11(156.66,72.72) v11(156.66,71.82) v11(156.71,68.53) v11(156.79,66.6) v11(156.99,70) v11(157.15,68.4) v11(157.15,67.72) v11(157.15,67.21) v11(157.17,66.65) v11(157.56,81.72) v11(157.56,80.82) v11(157.56,79.02) v11(157.56,76.32) v11(157.56,75.42) v11(157.56,74.52) v11(157.56,73.62) v11(157.56,72.72) v11(157.56,71.82) v11(157.76,84.48) v11(157.76,70) v11(158.46,80.82) v11(158.46,77.22) v11(158.46,75.42) v11(158.46,74.52) v11(158.46,73.62) v11(158.46,72.72) v11(158.46,71.82) v11(158.52,70) v11(158.9,84.48) v11(159.03,70) v11(159.36,76.32) v11(159.53,70) v11(160.17,84.48) v11(160.19,68.35) v11(160.26,81.72) v11(160.26,79.92) v11(160.26,77.22) v11(160.26,75.42) v11(160.26,74.52) v11(160.26,73.62) v11(160.26,72.72) v11(160.26,71.82) v11(160.68,70) v11(160.93,68.45) v11(161.16,82.62) v11(161.16,80.82) v11(161.16,79.02) v11(161.16,78.12) v11(161.16,75.42) v11(161.16,74.52) v11(161.16,73.62) v11(161.16,72.72) v11(161.16,71.82) v11(161.44,84.48) v11(161.44,72.26) v11(161.49,71.45) v11(161.72,72.47) v11(161.77,71.2) v11(161.95,70) v11(162.06,82.62) v11(162.06,80.82) v11(162.06,79.01) v11(162.06,78.11) v11(162.06,77.22) v11(162.06,76.32) v11(162.06,75.42) v11(162.06,74.52) v11(162.06,73.62) v11(162.06,72.72) v11(162.1,71.12) v11(162.43,71.12) v11(162.56,72.49) v11(162.71,84.48) v11(162.81,71.12) v11(163.01,72.49) v11(162.96,68.99) v11(163.17,71.12) v11(163.22,70) v11(163.45,72.49) v11(163.5,71.12) v11(163.85,72.49) v11(163.88,71.12) v11(163.98,84.48) v11(164,84) v11(164.11,82.7) v11(164.11,78.64) v11(164.11,77.37) v11(164.11,76.1) v11(164.11,74.83) v11(164.11,73.56) v11(164.11,70.51) v11(164.23,71.12) v11(164.26,72.49) v11(164.36,81.69) v11(164.36,80.8) v11(164.36,79.91) v11(164.64,72.49) v11(164.59,71.15) v11(164.94,71.15) v11(164.87,69.85) v11(165.02,72.49) v11(165.38,72.49) v11(165.35,71.15) v11(165.73,72.49) v11(165.76,81.21) v11(165.81,71.15) v11(166.11,72.49) v11(166.16,71.15) v11(166.49,72.49) v11(166.57,71.15) v11(166.85,72.47) v11(166.93,71.12) v11(167.13,68.99) v11(167.1,68.63) v11(167.1,68.28) v11(167.23,72.47) v11(167.15,70.11) v11(167.18,69.32) v11(167.23,67.67) v11(167.31,71.12) v11(167.31,70.79) v11(167.31,70.44) v11(167.31,69.8) v11(167.56,72.44) v11(167.92,72.47) v11(167.92,67.72) v11(168.32,72.42) v11(168.58,72.16) v11(168.55,67.67) v11(168.68,71.83) v11(168.68,71.5) v11(168.68,71.17) v11(168.68,70.82) v11(168.68,70.46) v11(168.68,70.13) v11(168.68,69.8) v11(168.83,69.45) v11(168.93,69.11) v11(168.93,68.68) v11(168.93,68.23) v11(168.96,67.64) v12(25.68,52.71) v12(26.08,51.84) v12(26.06,50.93) v12(26.13,48.08) v12(26.23,58.5) v12(26.36,53.06) v12(26.54,55.27) v12(26.67,64.87) v12(26.84,70.03) v12(26.77,66.93) v12(26.87,62.79) v12(26.95,59.49) v12(26.97,60.91) v12(27.07,77.07) v12(27.68,68.48) v12(27.66,63.76) v12(27.73,47.8) v12(27.78,69.65) v12(27.76,67.31) v12(28.01,65.66) v12(28.01,55.65) v12(28.24,62.71) v12(28.24,61.01) v12(28.27,59.69) v12(28.39,58.47) v12(28.57,64.62) v12(29.03,54.97) v12(29.11,70.33) v12(29.13,68.02) v12(29.05,67.01) v12(29.16,69.22) v12(29.33,47.73) v12(29.51,64.72) v12(30.17,49.1) v12(30.45,64.57) v12(30.45,56.41) v12(31.09,49.23) v12(31.24,47.75) v12(32.58,47.75) v12(34.16,47.75) v12(35.63,52.58) v12(35.66,47.75) v12(37.94,47.75) v12(39.8,47.78) v12(40.2,79.58) v12(41.25,79.63) v12(41.17,48.95) v12(42.36,49.94) v12(42.64,79.63) v12(43.3,50.78) v12(43.53,79.63) v12(50.34,60.94) v12(52.91,61.01) v12(53.31,65.15) v12(53.34,63.22) v12(53.36,66.98) v12(54.58,65.61) v12(57.78,71.71) v12(58.29,66.78) v12(58.49,68.73) v12(59.56,68) v12(59.74,66.75) v13(2.56,68.23) v13(9.8,72.16) v13(16.28,84.74) v13(16.28,29.74) v13(19.07,10.44) v13(33.17,6.5) v13(34.67,54.54) v13(35.96,66.85) v13(38,42.5) v13(40.79,82.58) v13(42.14,10.09) v13(42.95,50.19) v13(43.33,76.61) v13(45.23,70.26) v13(47.14,44.35) v13(53.87,82.65) v13(66.19,84.61) v13(66.32,64.29) v13(68.35,57.18) v13(74.83,71.65) v13(78.76,71.78) v13(80.03,37.49) v13(80.54,83.59) v13(81.68,83.59) v13(98.83,66.57) v13(98.96,54.13) v13(103.02,84.48) v13(105.81,83.97) v13(105.94,50.57) v13(116.86,34.57) v13(127.66,60.48) v13(130.07,67.72) v13(134.9,82.32) v13(148.23,83.97) v13(169.69,72.67) v13(172.11,72.54) v14(102.64,51.97) v14(102.64,51.21) v14(103.4,51.97) v14(103.4,51.21) v14(105.53,45.24) v14(105.56,44.35) v14(105.56,43.59) v14(105.56,42.83) v14(106.3,45.24) v14(106.32,44.35) v14(106.32,43.59) v14(106.32,42.83) v14(107.06,45.24) v14(107.08,44.35) v14(107.08,43.59) v14(107.08,42.83) v14(146.31,72.84)
